* NGSPICE file created from dff_ram_4x72.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

.subckt dff_ram_4x72 VGND VPWR address[0] address[1] clk en rdata[0] rdata[10] rdata[11]
+ rdata[12] rdata[13] rdata[14] rdata[15] rdata[16] rdata[17] rdata[18] rdata[19]
+ rdata[1] rdata[20] rdata[21] rdata[22] rdata[23] rdata[24] rdata[25] rdata[26] rdata[27]
+ rdata[28] rdata[29] rdata[2] rdata[30] rdata[31] rdata[32] rdata[33] rdata[34] rdata[35]
+ rdata[36] rdata[37] rdata[38] rdata[39] rdata[3] rdata[40] rdata[41] rdata[42] rdata[43]
+ rdata[44] rdata[45] rdata[46] rdata[47] rdata[48] rdata[49] rdata[4] rdata[50] rdata[51]
+ rdata[52] rdata[53] rdata[54] rdata[55] rdata[56] rdata[57] rdata[58] rdata[59]
+ rdata[5] rdata[60] rdata[61] rdata[62] rdata[63] rdata[64] rdata[65] rdata[66] rdata[67]
+ rdata[68] rdata[69] rdata[6] rdata[70] rdata[71] rdata[7] rdata[8] rdata[9] wdata[0]
+ wdata[10] wdata[11] wdata[12] wdata[13] wdata[14] wdata[15] wdata[16] wdata[17]
+ wdata[18] wdata[19] wdata[1] wdata[20] wdata[21] wdata[22] wdata[23] wdata[24] wdata[25]
+ wdata[26] wdata[27] wdata[28] wdata[29] wdata[2] wdata[30] wdata[31] wdata[32] wdata[33]
+ wdata[34] wdata[35] wdata[36] wdata[37] wdata[38] wdata[39] wdata[3] wdata[40] wdata[41]
+ wdata[42] wdata[43] wdata[44] wdata[45] wdata[46] wdata[47] wdata[48] wdata[49]
+ wdata[4] wdata[50] wdata[51] wdata[52] wdata[53] wdata[54] wdata[55] wdata[56] wdata[57]
+ wdata[58] wdata[59] wdata[5] wdata[60] wdata[61] wdata[62] wdata[63] wdata[64] wdata[65]
+ wdata[66] wdata[67] wdata[68] wdata[69] wdata[6] wdata[70] wdata[71] wdata[7] wdata[8]
+ wdata[9] wr_n
X_2037_ clknet_leaf_0_clk _0249_ VGND VGND VPWR VPWR mem\[1\]\[33\] sky130_fd_sc_hd__dfxtp_1
X_2106_ clknet_leaf_1_clk net267 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfxtp_1
Xhold362 mem\[2\]\[57\] VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__dlygate4sd3_1
Xhold351 mem\[0\]\[64\] VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__dlygate4sd3_1
Xhold340 mem\[0\]\[39\] VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__dlygate4sd3_1
Xhold384 mem\[1\]\[48\] VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__dlygate4sd3_1
Xhold395 mem\[1\]\[57\] VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__dlygate4sd3_1
Xhold373 mem\[2\]\[11\] VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1270_ net27 net522 _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0985_ net270 net39 _0832_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1606_ mem\[3\]\[20\] _0586_ _0617_ mem\[0\]\[20\] VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__a22o_1
XFILLER_0_14_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1468_ _0557_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__clkbuf_1
X_1399_ net13 net502 _0512_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__mux2_1
X_1537_ mem\[3\]\[2\] _0599_ _0600_ mem\[1\]\[2\] _0594_ VGND VGND VPWR VPWR _0603_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_49_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold181 net131 VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__dlygate4sd3_1
Xhold170 mem\[3\]\[27\] VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__dlygate4sd3_1
Xhold192 mem\[0\]\[29\] VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_28_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1322_ net54 net368 _0473_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1253_ net18 net471 _0440_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__mux2_1
X_1184_ net63 net369 _0401_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_20_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0968_ net288 net30 _0821_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__mux2_1
X_0899_ net421 net4 _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1940_ clknet_leaf_21_clk _0152_ VGND VGND VPWR VPWR mem\[2\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1871_ clknet_leaf_24_clk _0083_ VGND VGND VPWR VPWR mem\[0\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1305_ net45 net564 _0462_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__mux2_1
X_1236_ net9 net470 _0429_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__mux2_1
X_1167_ net54 net405 _0390_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__mux2_1
X_1098_ net18 net485 _0891_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_38_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2070_ clknet_leaf_15_clk _0282_ VGND VGND VPWR VPWR mem\[1\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_1021_ _0852_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1854_ clknet_leaf_14_clk _0066_ VGND VGND VPWR VPWR mem\[3\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_1923_ clknet_leaf_15_clk _0135_ VGND VGND VPWR VPWR mem\[0\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_1785_ mem\[3\]\[71\] _0599_ _0600_ mem\[1\]\[71\] VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__a22o_1
XFILLER_0_24_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1219_ net70 net520 _0418_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold41 mem\[2\]\[35\] VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold30 _0294_ VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 _0302_ VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 net89 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dlygate4sd3_1
Xhold74 _0312_ VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_51_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold96 _0674_ VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__dlygate4sd3_1
Xhold85 net91 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_60_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1570_ mem\[3\]\[10\] _0586_ _0597_ mem\[2\]\[10\] VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__a22o_1
X_2053_ clknet_leaf_5_clk _0265_ VGND VGND VPWR VPWR mem\[1\]\[49\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_49_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2122_ clknet_leaf_9_clk net265 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dfxtp_1
X_1004_ net287 net49 _0843_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1837_ clknet_leaf_6_clk _0049_ VGND VGND VPWR VPWR mem\[3\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_1906_ clknet_leaf_9_clk _0118_ VGND VGND VPWR VPWR mem\[0\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_1768_ net223 _0757_ _0768_ _0770_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__o22a_1
XFILLER_0_4_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1699_ mem\[0\]\[45\] _0651_ _0721_ mem\[1\]\[45\] VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__a22o_1
XFILLER_0_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput86 net86 VGND VGND VPWR VPWR rdata[18] sky130_fd_sc_hd__clkbuf_4
Xoutput97 net97 VGND VGND VPWR VPWR rdata[28] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1622_ _0607_ _0608_ mem\[3\]\[24\] VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__and3_1
X_1484_ _0565_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__clkbuf_1
X_1553_ mem\[3\]\[5\] _0599_ _0591_ mem\[2\]\[5\] _0594_ VGND VGND VPWR VPWR _0616_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2036_ clknet_leaf_1_clk _0248_ VGND VGND VPWR VPWR mem\[1\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_2105_ clknet_leaf_28_clk net194 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold330 mem\[2\]\[68\] VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold352 mem\[2\]\[70\] VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__dlygate4sd3_1
Xhold341 mem\[1\]\[0\] VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__dlygate4sd3_1
Xhold374 mem\[2\]\[30\] VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__dlygate4sd3_1
Xhold396 mem\[0\]\[13\] VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__dlygate4sd3_1
Xhold385 mem\[1\]\[7\] VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__dlygate4sd3_1
Xhold363 mem\[1\]\[5\] VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0984_ _0833_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
X_1605_ net159 _0634_ _0652_ _0653_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__o22a_1
XFILLER_0_1_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1536_ mem\[0\]\[2\] _0596_ _0597_ mem\[2\]\[2\] VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_57_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1467_ net49 net445 _0556_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__mux2_1
X_1398_ _0520_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__clkbuf_1
X_2019_ clknet_leaf_25_clk _0231_ VGND VGND VPWR VPWR mem\[1\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold171 mem\[3\]\[68\] VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlygate4sd3_1
Xhold193 mem\[2\]\[48\] VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__dlygate4sd3_1
Xhold160 mem\[3\]\[63\] VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__dlygate4sd3_1
Xhold182 mem\[3\]\[29\] VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_59_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1321_ _0478_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__clkbuf_1
X_1252_ _0442_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_62_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1183_ _0404_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0967_ _0824_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
X_1519_ _0498_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__buf_4
X_0898_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__buf_4
XFILLER_0_10_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1870_ clknet_leaf_22_clk _0082_ VGND VGND VPWR VPWR mem\[0\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_24_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1166_ _0395_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__clkbuf_1
X_1304_ _0469_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__clkbuf_1
X_1235_ _0433_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1097_ _0893_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__clkbuf_1
X_1999_ clknet_leaf_13_clk _0211_ VGND VGND VPWR VPWR mem\[2\]\[67\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_38_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1020_ net271 net57 _0843_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1922_ clknet_leaf_13_clk _0134_ VGND VGND VPWR VPWR mem\[0\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_1853_ clknet_leaf_17_clk _0065_ VGND VGND VPWR VPWR mem\[3\]\[65\] sky130_fd_sc_hd__dfxtp_1
X_1784_ net209 _0757_ _0779_ _0781_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__o22a_1
X_1149_ _0386_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_27_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1218_ _0424_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_35_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold53 net122 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__dlygate4sd3_1
Xhold75 net138 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 _0323_ VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 _0298_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 net148 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 _0308_ VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 _0310_ VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dlygate4sd3_1
Xhold97 _0314_ VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2052_ clknet_leaf_5_clk _0264_ VGND VGND VPWR VPWR mem\[1\]\[48\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_49_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2121_ clknet_leaf_5_clk net228 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dfxtp_1
X_1003_ _0787_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__buf_4
XFILLER_0_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1905_ clknet_leaf_5_clk _0117_ VGND VGND VPWR VPWR mem\[0\]\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1836_ clknet_leaf_6_clk _0048_ VGND VGND VPWR VPWR mem\[3\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_1767_ mem\[0\]\[65\] _0683_ _0716_ mem\[1\]\[65\] _0769_ VGND VGND VPWR VPWR _0770_
+ sky130_fd_sc_hd__a221o_1
X_1698_ _0498_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__buf_4
XFILLER_0_4_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput98 net98 VGND VGND VPWR VPWR rdata[29] sky130_fd_sc_hd__clkbuf_4
Xoutput87 net87 VGND VGND VPWR VPWR rdata[19] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_46_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1621_ mem\[2\]\[24\] _0597_ _0604_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__a21o_1
X_1552_ mem\[0\]\[5\] _0596_ _0587_ mem\[1\]\[5\] VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__a22o_1
X_1483_ net57 net302 _0556_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__mux2_1
X_2104_ clknet_leaf_29_clk net218 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2035_ clknet_leaf_1_clk _0247_ VGND VGND VPWR VPWR mem\[1\]\[31\] sky130_fd_sc_hd__dfxtp_1
Xhold353 net140 VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__dlygate4sd3_1
Xhold320 mem\[0\]\[61\] VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__dlygate4sd3_1
Xhold397 mem\[1\]\[42\] VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__dlygate4sd3_1
Xhold342 net108 VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__dlygate4sd3_1
Xhold386 mem\[1\]\[23\] VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__dlygate4sd3_1
Xhold364 mem\[1\]\[21\] VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__dlygate4sd3_1
Xhold331 mem\[2\]\[7\] VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__dlygate4sd3_1
Xhold375 mem\[2\]\[5\] VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__dlygate4sd3_1
X_1819_ clknet_leaf_1_clk _0031_ VGND VGND VPWR VPWR mem\[3\]\[31\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_43_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0983_ net372 net38 _0832_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1535_ net185 _0583_ _0598_ _0601_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__o22a_1
X_1604_ mem\[3\]\[19\] _0599_ _0639_ mem\[2\]\[19\] _0624_ VGND VGND VPWR VPWR _0653_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_1_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1466_ _0500_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__buf_4
X_1397_ net12 net386 _0512_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__mux2_1
X_2018_ clknet_leaf_26_clk _0230_ VGND VGND VPWR VPWR mem\[1\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold172 mem\[3\]\[48\] VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__dlygate4sd3_1
Xhold194 mem\[2\]\[60\] VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__dlygate4sd3_1
Xhold183 mem\[0\]\[38\] VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__dlygate4sd3_1
Xhold150 mem\[0\]\[4\] VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__dlygate4sd3_1
Xhold161 mem\[3\]\[18\] VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1320_ net53 net535 _0473_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__mux2_1
X_1182_ net62 net451 _0401_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__mux2_1
X_1251_ net17 net554 _0440_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_62_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0897_ _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__clkbuf_4
X_0966_ net268 net29 _0821_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1449_ _0547_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__clkbuf_1
X_1518_ _0585_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_2_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1303_ net44 net487 _0462_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1165_ net53 net415 _0390_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1096_ net17 net474 _0891_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__mux2_1
X_1234_ net8 net434 _0429_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__mux2_1
X_1998_ clknet_leaf_14_clk _0210_ VGND VGND VPWR VPWR mem\[2\]\[66\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0949_ net290 net20 _0810_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_38_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1921_ clknet_leaf_17_clk _0133_ VGND VGND VPWR VPWR mem\[0\]\[61\] sky130_fd_sc_hd__dfxtp_1
X_1852_ clknet_leaf_16_clk _0064_ VGND VGND VPWR VPWR mem\[3\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_1783_ mem\[0\]\[70\] _0683_ _0619_ mem\[2\]\[70\] _0780_ VGND VGND VPWR VPWR _0781_
+ sky130_fd_sc_hd__a221o_1
X_1148_ net44 net551 _0379_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_35_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1079_ net8 net544 _0880_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__mux2_1
X_1217_ net59 net523 _0418_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold54 _0338_ VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 net120 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 net118 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__dlygate4sd3_1
Xhold76 _0353_ VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 net107 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 _0311_ VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 net84 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 _0297_ VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 net94 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_42_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2120_ clknet_leaf_2_clk net242 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dfxtp_1
X_1002_ _0842_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
X_2051_ clknet_leaf_7_clk _0263_ VGND VGND VPWR VPWR mem\[1\]\[47\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_49_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1835_ clknet_leaf_7_clk _0047_ VGND VGND VPWR VPWR mem\[3\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1904_ clknet_leaf_3_clk _0116_ VGND VGND VPWR VPWR mem\[0\]\[44\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_32_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1766_ _0611_ _0785_ mem\[3\]\[65\] VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__and3_1
X_1697_ net241 _0695_ _0718_ _0720_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__o22a_1
XFILLER_0_12_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput88 net88 VGND VGND VPWR VPWR rdata[1] sky130_fd_sc_hd__clkbuf_4
Xoutput77 net77 VGND VGND VPWR VPWR rdata[0] sky130_fd_sc_hd__buf_2
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput99 net99 VGND VGND VPWR VPWR rdata[2] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_46_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1482_ _0564_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__clkbuf_1
X_1551_ _0614_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1620_ _0582_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__clkbuf_4
X_2103_ clknet_leaf_28_clk net164 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfxtp_1
X_2034_ clknet_leaf_1_clk _0246_ VGND VGND VPWR VPWR mem\[1\]\[30\] sky130_fd_sc_hd__dfxtp_1
Xhold310 _0342_ VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_32_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1818_ clknet_leaf_1_clk _0030_ VGND VGND VPWR VPWR mem\[3\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold398 mem\[1\]\[45\] VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__dlygate4sd3_1
Xhold365 mem\[2\]\[51\] VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__dlygate4sd3_1
Xhold376 mem\[2\]\[43\] VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__dlygate4sd3_1
Xhold387 mem\[2\]\[54\] VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__dlygate4sd3_1
X_1749_ _0582_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__clkbuf_4
Xhold332 mem\[2\]\[19\] VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__dlygate4sd3_1
Xhold343 mem\[2\]\[25\] VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__dlygate4sd3_1
Xhold354 mem\[1\]\[18\] VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__dlygate4sd3_1
Xhold321 mem\[3\]\[5\] VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_39_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_48_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_57_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0982_ _0787_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__buf_4
X_1465_ _0555_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__clkbuf_1
X_1534_ mem\[3\]\[1\] _0599_ _0600_ mem\[1\]\[1\] _0594_ VGND VGND VPWR VPWR _0601_
+ sky130_fd_sc_hd__a221o_1
X_1603_ mem\[0\]\[19\] _0651_ _0637_ mem\[1\]\[19\] VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1396_ _0519_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__clkbuf_1
X_2017_ clknet_leaf_23_clk _0229_ VGND VGND VPWR VPWR mem\[1\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold151 mem\[3\]\[47\] VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlygate4sd3_1
Xhold140 mem\[3\]\[33\] VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__dlygate4sd3_1
Xhold162 mem\[3\]\[4\] VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold195 mem\[2\]\[41\] VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__dlygate4sd3_1
Xhold173 mem\[3\]\[17\] VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold184 mem\[3\]\[16\] VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1181_ _0403_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__clkbuf_1
X_1250_ _0441_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_19_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0896_ net3 net76 _0784_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__and4bb_1
X_0965_ _0823_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
X_1448_ net39 net304 _0545_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__mux2_1
X_1517_ _0584_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_4_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1379_ _0510_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_16_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_24_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1302_ _0468_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__clkbuf_1
X_1233_ _0432_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1164_ _0394_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__clkbuf_1
X_1095_ _0892_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__clkbuf_1
X_1997_ clknet_leaf_17_clk _0209_ VGND VGND VPWR VPWR mem\[2\]\[65\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0948_ _0814_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_38_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1920_ clknet_leaf_13_clk _0132_ VGND VGND VPWR VPWR mem\[0\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_1851_ clknet_leaf_14_clk _0063_ VGND VGND VPWR VPWR mem\[3\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_1782_ _0611_ _0785_ mem\[3\]\[70\] VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__and3_1
XFILLER_0_12_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1216_ _0423_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1147_ _0385_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_35_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1078_ _0883_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold11 net87 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 _0304_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 _0337_ VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 _0335_ VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 net109 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 _0325_ VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 net90 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 _0313_ VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 net146 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2050_ clknet_leaf_9_clk _0262_ VGND VGND VPWR VPWR mem\[1\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_1001_ net278 net47 _0832_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1903_ clknet_leaf_5_clk _0115_ VGND VGND VPWR VPWR mem\[0\]\[43\] sky130_fd_sc_hd__dfxtp_1
X_1834_ clknet_leaf_3_clk _0046_ VGND VGND VPWR VPWR mem\[3\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_1765_ mem\[2\]\[65\] _0597_ _0594_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_32_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1696_ mem\[2\]\[44\] _0669_ _0716_ mem\[1\]\[44\] _0719_ VGND VGND VPWR VPWR _0720_
+ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_27_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_11_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput78 net78 VGND VGND VPWR VPWR rdata[10] sky130_fd_sc_hd__clkbuf_4
Xoutput89 net89 VGND VGND VPWR VPWR rdata[20] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1481_ net56 net543 _0556_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__mux2_1
X_1550_ net563 _0613_ _0582_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2033_ clknet_leaf_29_clk _0245_ VGND VGND VPWR VPWR mem\[1\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_2102_ clknet_leaf_1_clk net245 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1748_ _0756_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__clkbuf_1
Xhold300 mem\[3\]\[45\] VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__dlygate4sd3_1
Xhold311 mem\[2\]\[64\] VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold344 mem\[0\]\[27\] VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__dlygate4sd3_1
X_1817_ clknet_leaf_29_clk _0029_ VGND VGND VPWR VPWR mem\[3\]\[29\] sky130_fd_sc_hd__dfxtp_1
Xhold322 mem\[2\]\[14\] VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__dlygate4sd3_1
Xhold333 mem\[1\]\[13\] VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__dlygate4sd3_1
Xhold388 net130 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__dlygate4sd3_1
Xhold355 mem\[2\]\[61\] VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__dlygate4sd3_1
X_1679_ net225 _0695_ _0705_ _0707_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__o22a_1
Xhold366 mem\[3\]\[25\] VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__dlygate4sd3_1
Xhold377 mem\[0\]\[15\] VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__dlygate4sd3_1
Xhold399 mem\[2\]\[37\] VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_48_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0981_ _0831_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1602_ _0589_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__buf_4
X_1464_ net47 net537 _0545_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1533_ _0498_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__buf_4
X_1395_ net11 net420 _0512_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2016_ clknet_leaf_19_clk _0228_ VGND VGND VPWR VPWR mem\[1\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_30_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_30_clk sky130_fd_sc_hd__clkbuf_8
Xhold163 mem\[1\]\[59\] VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold130 mem\[3\]\[49\] VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__dlygate4sd3_1
Xhold152 mem\[3\]\[38\] VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__dlygate4sd3_1
Xhold174 mem\[0\]\[35\] VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlygate4sd3_1
Xhold185 mem\[2\]\[28\] VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__dlygate4sd3_1
Xhold141 mem\[3\]\[15\] VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold196 mem\[2\]\[9\] VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_51_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_21_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_21_clk sky130_fd_sc_hd__clkbuf_8
X_1180_ net61 net468 _0401_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_19_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_12_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_54_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0964_ net465 net28 _0821_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1516_ _0784_ _0785_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__and2_1
X_0895_ net2 VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__buf_2
X_1447_ _0546_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1378_ net74 net446 _0501_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1301_ net43 net526 _0462_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_1_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_19_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1232_ net7 net496 _0429_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__mux2_1
X_1163_ net52 net380 _0390_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__mux2_1
X_1094_ net16 net519 _0891_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__mux2_1
X_1996_ clknet_leaf_17_clk _0208_ VGND VGND VPWR VPWR mem\[2\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_0947_ net367 net19 _0810_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1850_ clknet_leaf_14_clk _0062_ VGND VGND VPWR VPWR mem\[3\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_1781_ mem\[1\]\[70\] _0587_ _0594_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__a21o_1
XFILLER_0_46_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1146_ net43 net539 _0379_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__mux2_1
X_1215_ net48 net317 _0418_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1077_ net7 net361 _0880_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__mux2_1
X_1979_ clknet_leaf_9_clk _0191_ VGND VGND VPWR VPWR mem\[2\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold12 _0307_ VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 _0309_ VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 net98 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 net99 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 _0295_ VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 net119 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 _0327_ VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dlygate4sd3_1
Xhold89 mem\[1\]\[15\] VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_61_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1000_ _0841_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
X_1902_ clknet_leaf_4_clk _0114_ VGND VGND VPWR VPWR mem\[0\]\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1833_ clknet_leaf_5_clk _0045_ VGND VGND VPWR VPWR mem\[3\]\[45\] sky130_fd_sc_hd__dfxtp_1
X_1764_ net205 _0757_ _0766_ _0767_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__o22a_1
XFILLER_0_37_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1695_ _0607_ _0608_ mem\[3\]\[44\] VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__and3_1
XFILLER_0_12_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1129_ net34 net447 _0368_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput79 net79 VGND VGND VPWR VPWR rdata[11] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_54_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1480_ _0563_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2101_ clknet_leaf_28_clk net214 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2032_ clknet_leaf_29_clk _0244_ VGND VGND VPWR VPWR mem\[1\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1747_ net329 _0755_ _0581_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__mux2_1
Xhold356 net112 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__dlygate4sd3_1
Xhold378 mem\[2\]\[45\] VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1678_ mem\[0\]\[39\] _0683_ _0706_ mem\[2\]\[39\] _0670_ VGND VGND VPWR VPWR _0707_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_4_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold345 mem\[1\]\[27\] VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__dlygate4sd3_1
Xhold334 mem\[1\]\[28\] VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__dlygate4sd3_1
Xhold367 mem\[0\]\[14\] VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__dlygate4sd3_1
X_1816_ clknet_leaf_29_clk _0028_ VGND VGND VPWR VPWR mem\[3\]\[28\] sky130_fd_sc_hd__dfxtp_1
Xhold323 mem\[2\]\[22\] VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__dlygate4sd3_1
Xhold312 mem\[0\]\[17\] VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__dlygate4sd3_1
Xhold301 mem\[1\]\[34\] VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold389 mem\[1\]\[49\] VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_51_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0980_ net338 net36 _0821_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__mux2_1
X_1532_ _0584_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__buf_4
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1601_ net250 _0634_ _0648_ _0650_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__o22a_1
X_1463_ _0554_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_38_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1394_ _0518_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__clkbuf_1
X_2015_ clknet_leaf_18_clk _0227_ VGND VGND VPWR VPWR mem\[1\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold186 mem\[1\]\[55\] VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__dlygate4sd3_1
Xhold131 mem\[3\]\[35\] VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__dlygate4sd3_1
Xhold120 mem\[3\]\[32\] VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__dlygate4sd3_1
Xhold175 mem\[3\]\[37\] VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__dlygate4sd3_1
Xhold197 mem\[3\]\[14\] VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__dlygate4sd3_1
Xhold153 mem\[3\]\[13\] VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__dlygate4sd3_1
Xhold142 mem\[3\]\[24\] VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__dlygate4sd3_1
Xhold164 mem\[2\]\[17\] VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0894_ net1 VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__buf_4
X_0963_ _0822_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1515_ _0582_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__clkbuf_4
X_1446_ net38 net461 _0545_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_2_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1377_ _0509_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1162_ _0393_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__clkbuf_1
X_1300_ _0467_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__clkbuf_1
X_1231_ _0431_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1093_ _0868_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__buf_4
X_1995_ clknet_leaf_17_clk _0207_ VGND VGND VPWR VPWR mem\[2\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_0946_ _0813_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
X_1429_ net29 net557 _0534_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1780_ net153 _0757_ _0777_ _0778_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__o22a_1
X_1145_ _0384_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1214_ _0422_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1076_ _0882_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__clkbuf_1
X_1978_ clknet_leaf_9_clk _0190_ VGND VGND VPWR VPWR mem\[2\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_0929_ _0804_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
Xhold68 _0336_ VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 net116 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 net111 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 net137 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 _0317_ VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 _0290_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 net132 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_26_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1901_ clknet_leaf_8_clk _0113_ VGND VGND VPWR VPWR mem\[0\]\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1832_ clknet_leaf_3_clk _0044_ VGND VGND VPWR VPWR mem\[3\]\[44\] sky130_fd_sc_hd__dfxtp_1
X_1763_ mem\[0\]\[64\] _0683_ _0619_ mem\[2\]\[64\] _0746_ VGND VGND VPWR VPWR _0767_
+ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_40_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1694_ mem\[0\]\[44\] _0617_ _0604_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__a21o_1
X_1128_ _0375_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__clkbuf_1
X_1059_ _0873_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2100_ clknet_leaf_26_clk net222 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfxtp_1
X_2031_ clknet_leaf_28_clk _0243_ VGND VGND VPWR VPWR mem\[1\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_1815_ clknet_leaf_28_clk _0027_ VGND VGND VPWR VPWR mem\[3\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_1746_ mem\[0\]\[59\] mem\[1\]\[59\] mem\[2\]\[59\] mem\[3\]\[59\] _0784_ _0612_
+ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__mux4_1
Xhold357 mem\[2\]\[52\] VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__dlygate4sd3_1
Xhold368 mem\[0\]\[47\] VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__dlygate4sd3_1
Xhold379 mem\[2\]\[42\] VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__dlygate4sd3_1
Xhold313 mem\[1\]\[40\] VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold335 mem\[1\]\[39\] VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__dlygate4sd3_1
X_1677_ _0415_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__buf_4
Xhold346 mem\[0\]\[23\] VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold302 mem\[2\]\[34\] VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__dlygate4sd3_1
Xhold324 mem\[3\]\[2\] VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_51_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1462_ net46 net532 _0545_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__mux2_1
X_1531_ mem\[0\]\[1\] _0596_ _0597_ mem\[2\]\[1\] VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__a22o_1
X_1600_ mem\[0\]\[18\] _0606_ _0639_ mem\[2\]\[18\] _0649_ VGND VGND VPWR VPWR _0650_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_22_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1393_ net10 net237 _0512_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__mux2_1
X_2014_ clknet_leaf_23_clk _0226_ VGND VGND VPWR VPWR mem\[1\]\[10\] sky130_fd_sc_hd__dfxtp_1
Xhold110 net145 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__dlygate4sd3_1
Xhold154 mem\[1\]\[58\] VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__dlygate4sd3_1
Xhold176 mem\[3\]\[51\] VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__dlygate4sd3_1
Xhold132 mem\[3\]\[44\] VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__dlygate4sd3_1
X_1729_ _0607_ _0785_ mem\[3\]\[54\] VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__and3_1
Xhold121 mem\[3\]\[54\] VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__dlygate4sd3_1
Xhold198 mem\[1\]\[64\] VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__dlygate4sd3_1
Xhold143 mem\[3\]\[12\] VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__dlygate4sd3_1
Xhold187 mem\[3\]\[19\] VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__dlygate4sd3_1
Xhold165 mem\[3\]\[7\] VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0962_ net325 net27 _0821_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__mux2_1
X_1445_ _0500_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__buf_4
X_1514_ _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_2_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1376_ net73 net533 _0501_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1161_ net51 net355 _0390_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1092_ _0890_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__clkbuf_1
X_1230_ net6 net521 _0429_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__mux2_1
X_1994_ clknet_leaf_13_clk _0206_ VGND VGND VPWR VPWR mem\[2\]\[62\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0945_ net283 net18 _0810_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1428_ _0536_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__clkbuf_1
X_1359_ net3 net76 _0498_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__or3b_1
XFILLER_0_18_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1213_ net37 net528 _0418_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1144_ net42 net373 _0379_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__mux2_1
X_1075_ net6 net438 _0880_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__mux2_1
X_1977_ clknet_leaf_5_clk _0189_ VGND VGND VPWR VPWR mem\[2\]\[45\] sky130_fd_sc_hd__dfxtp_1
X_0928_ net345 net9 _0799_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__mux2_1
Xhold47 net124 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 _0328_ VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dlygate4sd3_1
Xhold58 _0352_ VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dlygate4sd3_1
Xhold69 net97 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 net104 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 _0293_ VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_26_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1831_ clknet_leaf_5_clk _0043_ VGND VGND VPWR VPWR mem\[3\]\[43\] sky130_fd_sc_hd__dfxtp_1
X_1900_ clknet_leaf_4_clk _0112_ VGND VGND VPWR VPWR mem\[0\]\[40\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_37_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1693_ net219 _0695_ _0715_ _0717_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_40_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1762_ mem\[3\]\[64\] _0599_ _0721_ mem\[1\]\[64\] VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__a22o_1
X_1127_ net33 net431 _0368_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__mux2_1
X_1058_ net37 net418 _0869_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_54_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2030_ clknet_leaf_30_clk _0242_ VGND VGND VPWR VPWR mem\[1\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1745_ _0754_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__clkbuf_1
X_1814_ clknet_leaf_30_clk _0026_ VGND VGND VPWR VPWR mem\[3\]\[26\] sky130_fd_sc_hd__dfxtp_1
Xhold336 mem\[0\]\[60\] VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__dlygate4sd3_1
Xhold303 mem\[0\]\[62\] VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__dlygate4sd3_1
Xhold347 mem\[1\]\[51\] VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__dlygate4sd3_1
Xhold314 mem\[1\]\[56\] VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__dlygate4sd3_1
X_1676_ mem\[3\]\[39\] _0672_ _0637_ mem\[1\]\[39\] VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__a22o_1
Xhold325 mem\[0\]\[6\] VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__dlygate4sd3_1
Xhold369 mem\[2\]\[23\] VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_15_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold358 mem\[0\]\[5\] VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_24_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_24_clk sky130_fd_sc_hd__clkbuf_8
X_1461_ _0553_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__clkbuf_1
X_1530_ _0415_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__buf_4
X_1392_ _0517_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_54_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2013_ clknet_leaf_21_clk _0225_ VGND VGND VPWR VPWR mem\[1\]\[9\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_15_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_8
Xhold122 mem\[3\]\[41\] VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__dlygate4sd3_1
X_1728_ net398 _0587_ _0594_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__a21o_1
Xhold111 _0359_ VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__dlygate4sd3_1
Xhold100 net106 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__dlygate4sd3_1
Xhold133 mem\[3\]\[11\] VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__dlygate4sd3_1
Xhold144 mem\[3\]\[9\] VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold155 mem\[3\]\[59\] VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlygate4sd3_1
Xhold166 mem\[2\]\[67\] VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlygate4sd3_1
Xhold188 mem\[2\]\[49\] VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__dlygate4sd3_1
Xhold177 mem\[3\]\[30\] VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__dlygate4sd3_1
Xhold199 mem\[3\]\[6\] VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1659_ mem\[0\]\[34\] _0651_ _0637_ mem\[1\]\[34\] VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_62_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0961_ _0787_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__buf_4
XFILLER_0_50_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1513_ _0580_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__buf_4
Xclkbuf_leaf_4_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_8
X_1444_ _0544_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1375_ _0508_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_45_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_18_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1160_ _0392_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__clkbuf_1
X_1091_ net14 net414 _0880_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1993_ clknet_leaf_11_clk _0205_ VGND VGND VPWR VPWR mem\[2\]\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0944_ _0812_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_15_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1358_ _0497_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__clkbuf_2
X_1427_ net28 net560 _0534_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__mux2_1
X_1289_ _0461_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_29_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_3_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1212_ _0421_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1143_ _0383_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__clkbuf_1
X_1074_ _0881_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1976_ clknet_leaf_3_clk _0188_ VGND VGND VPWR VPWR mem\[2\]\[44\] sky130_fd_sc_hd__dfxtp_1
X_0927_ _0803_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold48 _0340_ VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__dlygate4sd3_1
Xhold59 net113 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 net88 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_26_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold15 net96 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 _0322_ VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dlygate4sd3_1
X_1761_ net165 _0757_ _0764_ _0765_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__o22a_1
XFILLER_0_44_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1830_ clknet_leaf_3_clk _0042_ VGND VGND VPWR VPWR mem\[3\]\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1692_ mem\[2\]\[43\] _0669_ _0716_ mem\[1\]\[43\] _0709_ VGND VGND VPWR VPWR _0717_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_12_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1126_ _0374_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__clkbuf_1
X_1057_ _0872_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1959_ clknet_leaf_28_clk _0171_ VGND VGND VPWR VPWR mem\[2\]\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1744_ net536 _0753_ _0581_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold315 mem\[1\]\[10\] VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__dlygate4sd3_1
Xhold326 mem\[0\]\[21\] VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__dlygate4sd3_1
X_1813_ clknet_leaf_28_clk _0025_ VGND VGND VPWR VPWR mem\[3\]\[25\] sky130_fd_sc_hd__dfxtp_1
Xhold304 mem\[0\]\[8\] VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__dlygate4sd3_1
X_1675_ _0704_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold337 mem\[0\]\[22\] VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__dlygate4sd3_1
Xhold359 mem\[1\]\[36\] VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__dlygate4sd3_1
Xhold348 mem\[2\]\[12\] VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1109_ _0365_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__clkbuf_1
X_2089_ clknet_leaf_24_clk net240 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_32_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1460_ net45 net366 _0545_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__mux2_1
X_1391_ net9 net365 _0512_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2012_ clknet_leaf_21_clk _0224_ VGND VGND VPWR VPWR mem\[1\]\[8\] sky130_fd_sc_hd__dfxtp_1
Xhold134 mem\[3\]\[53\] VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__dlygate4sd3_1
Xhold123 mem\[3\]\[58\] VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__dlygate4sd3_1
X_1727_ _0741_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__clkbuf_1
Xhold167 mem\[3\]\[52\] VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlygate4sd3_1
Xhold156 mem\[1\]\[41\] VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__dlygate4sd3_1
Xhold145 mem\[1\]\[38\] VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__dlygate4sd3_1
X_1658_ _0692_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__clkbuf_1
Xhold101 _0324_ VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold112 net101 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__dlygate4sd3_1
Xhold178 mem\[2\]\[58\] VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__dlygate4sd3_1
Xhold189 mem\[1\]\[33\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__dlygate4sd3_1
X_1589_ _0607_ _0608_ mem\[3\]\[15\] VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__and3_1
XFILLER_0_36_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0960_ _0820_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1512_ net3 net76 VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__and2b_1
X_1443_ net36 net483 _0534_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__mux2_1
X_1374_ net70 net440 _0501_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_18_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_1_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1090_ _0889_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__clkbuf_1
X_1992_ clknet_leaf_13_clk _0204_ VGND VGND VPWR VPWR mem\[2\]\[60\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0943_ net352 net17 _0810_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_15_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1357_ net2 net1 VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__and2b_1
X_1288_ net36 net437 _0451_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__mux2_1
X_1426_ _0535_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_29_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1142_ net41 net548 _0379_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__mux2_1
X_1211_ net26 net419 _0418_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1073_ net5 net394 _0880_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__mux2_1
X_1975_ clknet_leaf_5_clk _0187_ VGND VGND VPWR VPWR mem\[2\]\[43\] sky130_fd_sc_hd__dfxtp_1
X_0926_ net301 net8 _0799_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold27 net135 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold38 _0289_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 _0315_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dlygate4sd3_1
X_1409_ _0526_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__clkbuf_1
Xhold49 net127 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_26_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1760_ mem\[3\]\[63\] _0585_ _0716_ mem\[1\]\[63\] _0746_ VGND VGND VPWR VPWR _0765_
+ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_40_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1691_ _0498_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1125_ net32 net322 _0368_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__mux2_1
X_1056_ net26 net402 _0869_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__mux2_1
X_1889_ clknet_leaf_29_clk _0101_ VGND VGND VPWR VPWR mem\[0\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1958_ clknet_leaf_30_clk _0170_ VGND VGND VPWR VPWR mem\[2\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_0909_ net469 net59 _0788_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_54_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1743_ mem\[0\]\[58\] mem\[1\]\[58\] mem\[2\]\[58\] mem\[3\]\[58\] _0784_ _0612_
+ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__mux4_1
Xhold305 mem\[0\]\[50\] VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__dlygate4sd3_1
Xhold316 mem\[0\]\[42\] VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__dlygate4sd3_1
X_1674_ net490 _0703_ _0581_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__mux2_1
Xhold338 mem\[1\]\[71\] VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__dlygate4sd3_1
Xhold349 mem\[0\]\[71\] VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__dlygate4sd3_1
Xhold327 mem\[2\]\[10\] VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__dlygate4sd3_1
X_1812_ clknet_leaf_1_clk _0024_ VGND VGND VPWR VPWR mem\[3\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_1039_ net276 net67 _0854_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__mux2_1
X_1108_ net23 net492 _0891_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__mux2_1
X_2088_ clknet_leaf_19_clk _0300_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_51_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1390_ _0516_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_54_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2011_ clknet_leaf_20_clk _0223_ VGND VGND VPWR VPWR mem\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1726_ net376 _0740_ _0581_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__mux2_1
Xhold157 mem\[1\]\[67\] VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__dlygate4sd3_1
Xhold179 mem\[3\]\[64\] VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__dlygate4sd3_1
X_1657_ net433 _0691_ _0581_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__mux2_1
Xhold168 mem\[2\]\[32\] VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__dlygate4sd3_1
Xhold124 net102 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__dlygate4sd3_1
Xhold146 mem\[3\]\[8\] VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold102 net86 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__dlygate4sd3_1
Xhold135 mem\[3\]\[22\] VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__dlygate4sd3_1
X_1588_ net237 _0587_ _0604_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__a21o_1
Xhold113 _0319_ VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_48_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_2_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1442_ _0543_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__clkbuf_1
X_1511_ _0579_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__clkbuf_1
X_1373_ _0507_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_61_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1709_ net246 _0727_ _0728_ _0729_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_1_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1991_ clknet_leaf_8_clk _0203_ VGND VGND VPWR VPWR mem\[2\]\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0942_ _0811_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1425_ net27 net531 _0534_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1287_ _0460_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__clkbuf_1
X_1356_ _0496_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1141_ _0382_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__clkbuf_1
X_1210_ _0420_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1072_ _0868_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__buf_4
X_1974_ clknet_leaf_5_clk _0186_ VGND VGND VPWR VPWR mem\[2\]\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0925_ _0802_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
Xhold28 _0350_ VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 net136 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dlygate4sd3_1
Xhold39 net110 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__dlygate4sd3_1
X_1408_ net18 net422 _0523_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__mux2_1
X_1339_ net63 net454 _0484_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_26_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1690_ mem\[3\]\[43\] _0672_ _0596_ mem\[0\]\[43\] VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_40_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1055_ _0871_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__clkbuf_1
X_1124_ _0373_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1957_ clknet_leaf_28_clk _0169_ VGND VGND VPWR VPWR mem\[2\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_0908_ _0793_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__clkbuf_1
X_1888_ clknet_leaf_29_clk _0100_ VGND VGND VPWR VPWR mem\[0\]\[28\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_27_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_27_clk sky130_fd_sc_hd__clkbuf_8
X_1811_ clknet_leaf_27_clk _0023_ VGND VGND VPWR VPWR mem\[3\]\[23\] sky130_fd_sc_hd__dfxtp_1
Xhold306 mem\[2\]\[63\] VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__dlygate4sd3_1
X_1742_ net252 _0727_ _0751_ _0752_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__o22a_1
XFILLER_0_40_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold339 mem\[2\]\[46\] VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__dlygate4sd3_1
X_1673_ mem\[0\]\[38\] mem\[1\]\[38\] mem\[2\]\[38\] mem\[3\]\[38\] _0611_ _0612_
+ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__mux4_1
XFILLER_0_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold328 mem\[2\]\[20\] VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__dlygate4sd3_1
Xhold317 mem\[3\]\[31\] VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1038_ _0861_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_18_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_8
X_2087_ clknet_leaf_18_clk _0299_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1107_ _0364_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_51_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2010_ clknet_leaf_19_clk _0222_ VGND VGND VPWR VPWR mem\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1725_ mem\[0\]\[53\] mem\[1\]\[53\] mem\[2\]\[53\] mem\[3\]\[53\] _0784_ _0612_
+ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__mux4_1
XFILLER_0_45_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_7_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_8
Xhold158 mem\[3\]\[62\] VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__dlygate4sd3_1
Xhold136 mem\[3\]\[65\] VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__dlygate4sd3_1
X_1656_ mem\[0\]\[33\] mem\[1\]\[33\] mem\[2\]\[33\] mem\[3\]\[33\] _0611_ _0612_
+ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__mux4_1
Xhold169 mem\[2\]\[4\] VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__dlygate4sd3_1
Xhold125 _0320_ VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__dlygate4sd3_1
Xhold114 net77 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__dlygate4sd3_1
X_1587_ net199 _0634_ _0638_ _0640_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__o22a_1
Xhold103 _0306_ VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__dlygate4sd3_1
Xhold147 mem\[3\]\[26\] VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__dlygate4sd3_1
X_2139_ clknet_leaf_15_clk net166 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1441_ net35 net293 _0534_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__mux2_1
X_1510_ net72 net486 _0500_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1372_ net59 net511 _0501_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_61_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1708_ mem\[3\]\[47\] _0680_ _0716_ mem\[1\]\[47\] _0709_ VGND VGND VPWR VPWR _0729_
+ sky130_fd_sc_hd__a221o_1
X_1639_ net217 _0664_ _0677_ _0678_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_1_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1990_ clknet_leaf_8_clk _0202_ VGND VGND VPWR VPWR mem\[2\]\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0941_ net378 net16 _0810_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_15_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_41_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_50_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1355_ net72 net423 _0417_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__mux2_1
X_1424_ _0500_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__buf_4
X_1286_ net35 net390 _0451_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_21_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1140_ net40 net464 _0379_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1071_ _0879_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1973_ clknet_leaf_7_clk _0185_ VGND VGND VPWR VPWR mem\[2\]\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0924_ net291 net7 _0799_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1338_ _0487_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__clkbuf_1
Xhold18 _0351_ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 net143 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dlygate4sd3_1
X_1407_ _0525_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_26_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1269_ _0417_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__buf_4
XFILLER_0_46_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1054_ net15 net498 _0869_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1123_ net31 net442 _0368_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0907_ net310 net48 _0788_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__mux2_1
X_1887_ clknet_leaf_28_clk _0099_ VGND VGND VPWR VPWR mem\[0\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1956_ clknet_leaf_26_clk _0168_ VGND VGND VPWR VPWR mem\[2\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1741_ mem\[2\]\[57\] _0669_ _0716_ mem\[1\]\[57\] _0746_ VGND VGND VPWR VPWR _0752_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_4_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1810_ clknet_leaf_26_clk _0022_ VGND VGND VPWR VPWR mem\[3\]\[22\] sky130_fd_sc_hd__dfxtp_1
Xhold329 mem\[0\]\[68\] VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold318 mem\[1\]\[70\] VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__dlygate4sd3_1
Xhold307 mem\[0\]\[0\] VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__dlygate4sd3_1
X_1672_ net235 _0695_ _0701_ _0702_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__o22a_1
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1106_ net22 net424 _0891_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1037_ net371 net66 _0854_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2086_ clknet_leaf_22_clk net168 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfxtp_1
X_1939_ clknet_leaf_19_clk _0151_ VGND VGND VPWR VPWR mem\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1724_ net195 _0727_ _0738_ _0739_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__o22a_1
Xhold104 net129 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dlygate4sd3_1
Xhold126 mem\[3\]\[46\] VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__dlygate4sd3_1
Xhold115 _0288_ VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold148 mem\[0\]\[67\] VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__dlygate4sd3_1
Xhold159 mem\[3\]\[55\] VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__dlygate4sd3_1
X_1655_ net272 _0664_ _0689_ _0690_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__o22a_1
X_1586_ mem\[3\]\[14\] _0599_ _0639_ mem\[2\]\[14\] _0624_ VGND VGND VPWR VPWR _0640_
+ sky130_fd_sc_hd__a221o_1
Xhold137 mem\[3\]\[3\] VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__dlygate4sd3_1
X_2138_ clknet_leaf_14_clk net176 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2069_ clknet_leaf_17_clk _0281_ VGND VGND VPWR VPWR mem\[1\]\[65\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_36_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1371_ _0506_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1440_ _0542_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_61_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1707_ mem\[0\]\[47\] _0651_ _0591_ mem\[2\]\[47\] VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__a22o_1
XFILLER_0_41_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1638_ mem\[2\]\[28\] _0669_ _0659_ mem\[1\]\[28\] _0670_ VGND VGND VPWR VPWR _0678_
+ sky130_fd_sc_hd__a221o_1
X_1569_ net179 _0583_ _0626_ _0627_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_1_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0940_ _0787_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__buf_4
XFILLER_0_42_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1354_ _0495_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__clkbuf_1
X_1285_ _0459_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__clkbuf_1
X_1423_ _0533_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1070_ net75 net375 _0869_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1972_ clknet_leaf_5_clk _0184_ VGND VGND VPWR VPWR mem\[2\]\[40\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_23_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0923_ _0801_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1337_ net62 net409 _0484_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__mux2_1
XFILLER_0_36_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1406_ net17 net512 _0523_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__mux2_1
Xhold19 net78 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dlygate4sd3_1
X_1268_ _0450_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
X_1199_ _0412_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_26_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1122_ _0372_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__clkbuf_1
X_1053_ _0870_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__clkbuf_1
X_1955_ clknet_leaf_27_clk _0167_ VGND VGND VPWR VPWR mem\[2\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_0906_ _0792_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
X_1886_ clknet_leaf_30_clk _0098_ VGND VGND VPWR VPWR mem\[0\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1740_ mem\[3\]\[57\] _0672_ _0596_ mem\[0\]\[57\] VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__a22o_1
Xhold308 mem\[0\]\[51\] VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1671_ mem\[2\]\[37\] _0669_ _0659_ mem\[1\]\[37\] _0670_ VGND VGND VPWR VPWR _0702_
+ sky130_fd_sc_hd__a221o_1
Xhold319 mem\[0\]\[25\] VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__dlygate4sd3_1
X_2085_ clknet_leaf_22_clk net180 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dfxtp_1
X_1105_ _0363_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1036_ _0860_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1869_ clknet_leaf_22_clk _0081_ VGND VGND VPWR VPWR mem\[0\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1938_ clknet_leaf_20_clk _0150_ VGND VGND VPWR VPWR mem\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_59_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_10_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1723_ mem\[2\]\[52\] _0669_ _0716_ mem\[1\]\[52\] _0709_ VGND VGND VPWR VPWR _0739_
+ sky130_fd_sc_hd__a221o_1
Xhold138 mem\[3\]\[61\] VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__dlygate4sd3_1
Xhold105 _0345_ VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__dlygate4sd3_1
Xhold149 mem\[3\]\[69\] VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__dlygate4sd3_1
Xhold116 net117 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__dlygate4sd3_1
Xhold127 mem\[3\]\[70\] VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__dlygate4sd3_1
X_1654_ mem\[0\]\[32\] _0617_ _0604_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1585_ _0415_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__buf_4
XFILLER_0_28_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2137_ clknet_leaf_11_clk net232 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dfxtp_1
X_1019_ _0851_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__clkbuf_1
X_2068_ clknet_leaf_16_clk _0280_ VGND VGND VPWR VPWR mem\[1\]\[64\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_4_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1370_ net48 net379 _0501_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_18_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1706_ _0582_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1637_ mem\[3\]\[28\] _0672_ _0617_ mem\[0\]\[28\] VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__a22o_1
X_1499_ _0573_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__clkbuf_1
X_1568_ mem\[2\]\[9\] _0619_ _0600_ mem\[1\]\[9\] _0624_ VGND VGND VPWR VPWR _0627_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_36_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_1_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1422_ net25 net391 _0523_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1353_ net71 net500 _0417_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__mux2_1
X_1284_ net34 net547 _0451_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0999_ net320 net46 _0832_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1971_ clknet_leaf_4_clk _0183_ VGND VGND VPWR VPWR mem\[2\]\[39\] sky130_fd_sc_hd__dfxtp_1
X_0922_ net281 net6 _0799_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1405_ _0524_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__clkbuf_1
Xinput1 address[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__dlymetal6s2s_1
X_1336_ _0486_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__clkbuf_1
X_1198_ net71 net416 _0868_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__mux2_1
X_1267_ net25 net399 _0440_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1052_ net4 net455 _0869_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__mux2_1
X_1121_ net30 net353 _0368_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_38_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1954_ clknet_leaf_26_clk _0166_ VGND VGND VPWR VPWR mem\[2\]\[22\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_47_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1885_ clknet_leaf_28_clk _0097_ VGND VGND VPWR VPWR mem\[0\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0905_ net285 net37 _0788_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__mux2_1
X_1319_ _0477_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold309 net126 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__dlygate4sd3_1
X_1670_ mem\[3\]\[37\] _0672_ _0617_ mem\[0\]\[37\] VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__a22o_1
XFILLER_0_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1035_ net284 net65 _0854_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__mux2_1
X_1104_ net21 net467 _0891_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__mux2_1
X_2084_ clknet_leaf_21_clk net150 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1937_ clknet_leaf_20_clk _0149_ VGND VGND VPWR VPWR mem\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1868_ clknet_leaf_21_clk _0080_ VGND VGND VPWR VPWR mem\[0\]\[8\] sky130_fd_sc_hd__dfxtp_1
Xinput70 wdata[6] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__buf_1
X_1799_ clknet_leaf_25_clk _0011_ VGND VGND VPWR VPWR mem\[3\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_59_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1722_ mem\[3\]\[52\] _0672_ _0596_ mem\[0\]\[52\] VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__a22o_1
Xhold128 mem\[3\]\[67\] VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__dlygate4sd3_1
Xhold139 mem\[3\]\[50\] VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__dlygate4sd3_1
Xhold117 _0334_ VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__dlygate4sd3_1
Xhold106 net128 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__dlygate4sd3_1
X_1653_ mem\[2\]\[32\] _0415_ _0498_ mem\[1\]\[32\] _0688_ VGND VGND VPWR VPWR _0689_
+ sky130_fd_sc_hd__a221o_1
X_1584_ mem\[0\]\[14\] _0596_ _0637_ mem\[1\]\[14\] VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2136_ clknet_leaf_13_clk net230 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2067_ clknet_leaf_15_clk _0279_ VGND VGND VPWR VPWR mem\[1\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_1018_ net429 net56 _0843_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_4_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_61_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1705_ net264 _0695_ _0724_ _0726_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__o22a_1
XFILLER_0_14_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1636_ net163 _0664_ _0675_ _0676_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__o22a_1
X_1567_ mem\[3\]\[9\] _0586_ _0617_ mem\[0\]\[9\] VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__a22o_1
X_2119_ clknet_leaf_7_clk net220 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dfxtp_1
X_1498_ net65 net411 _0567_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__mux2_1
XFILLER_0_36_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1421_ _0532_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__clkbuf_1
X_1352_ _0494_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__clkbuf_1
X_1283_ _0458_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__clkbuf_1
X_0998_ _0840_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1619_ net157 _0634_ _0662_ _0663_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__o22a_1
XFILLER_0_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1970_ clknet_leaf_4_clk _0182_ VGND VGND VPWR VPWR mem\[2\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_0921_ _0800_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
X_1335_ net61 net503 _0484_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__mux2_1
X_1404_ net16 net408 _0523_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__mux2_1
Xinput2 address[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_1
X_1197_ _0411_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1266_ _0449_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_34_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1120_ _0371_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__clkbuf_1
X_1051_ _0868_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__buf_4
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1953_ clknet_leaf_28_clk _0165_ VGND VGND VPWR VPWR mem\[2\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_1884_ clknet_leaf_26_clk _0096_ VGND VGND VPWR VPWR mem\[0\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_0904_ _0791_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1318_ net52 net392 _0473_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1249_ net16 net476 _0440_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_45_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1034_ _0859_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__clkbuf_1
X_1103_ _0362_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__clkbuf_1
X_2083_ clknet_leaf_20_clk net204 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1936_ clknet_leaf_18_clk _0148_ VGND VGND VPWR VPWR mem\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1867_ clknet_leaf_19_clk _0079_ VGND VGND VPWR VPWR mem\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xinput60 wdata[60] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_1
Xinput71 wdata[70] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__buf_1
X_1798_ clknet_leaf_22_clk _0010_ VGND VGND VPWR VPWR mem\[3\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_59_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1721_ net256 _0727_ _0736_ _0737_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__o22a_1
X_1583_ _0498_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__buf_4
Xhold129 mem\[3\]\[56\] VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__dlygate4sd3_1
Xhold107 _0344_ VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dlygate4sd3_1
X_1652_ _0611_ _0785_ mem\[3\]\[32\] VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__and3_1
Xhold118 net100 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2135_ clknet_leaf_8_clk _0347_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dfxtp_1
X_2066_ clknet_leaf_13_clk _0278_ VGND VGND VPWR VPWR mem\[1\]\[62\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1017_ _0850_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1919_ clknet_leaf_8_clk _0131_ VGND VGND VPWR VPWR mem\[0\]\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1704_ mem\[0\]\[46\] _0683_ _0716_ mem\[1\]\[46\] _0725_ VGND VGND VPWR VPWR _0726_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_30_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1497_ _0572_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__clkbuf_1
X_1635_ mem\[3\]\[27\] _0599_ _0639_ mem\[2\]\[27\] _0670_ VGND VGND VPWR VPWR _0676_
+ sky130_fd_sc_hd__a221o_1
X_1566_ net149 _0583_ _0623_ _0625_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__o22a_1
XFILLER_0_55_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2049_ clknet_leaf_5_clk _0261_ VGND VGND VPWR VPWR mem\[1\]\[45\] sky130_fd_sc_hd__dfxtp_1
X_2118_ clknet_leaf_3_clk net208 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1351_ net69 net374 _0484_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__mux2_1
X_1420_ net24 net482 _0523_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__mux2_1
X_1282_ net33 net436 _0451_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0997_ net299 net45 _0832_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1618_ mem\[0\]\[23\] _0606_ _0639_ mem\[2\]\[23\] _0624_ VGND VGND VPWR VPWR _0663_
+ sky130_fd_sc_hd__a221o_1
X_1549_ mem\[0\]\[4\] mem\[1\]\[4\] mem\[2\]\[4\] mem\[3\]\[4\] _0611_ _0612_ VGND
+ VGND VPWR VPWR _0613_ sky130_fd_sc_hd__mux4_1
XFILLER_0_1_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold290 mem\[0\]\[11\] VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0920_ net328 net5 _0799_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1334_ _0485_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__clkbuf_1
X_1265_ net24 net333 _0440_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1403_ _0500_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__buf_4
X_1196_ net69 net358 _0401_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__mux2_1
Xinput3 en VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1050_ _0867_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_31_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1883_ clknet_leaf_27_clk _0095_ VGND VGND VPWR VPWR mem\[0\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1952_ clknet_leaf_26_clk _0164_ VGND VGND VPWR VPWR mem\[2\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_0903_ net472 net26 _0788_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1317_ _0476_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1248_ _0417_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__buf_4
X_1179_ _0402_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1102_ net20 net359 _0891_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2082_ clknet_leaf_20_clk net178 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1033_ net327 net64 _0854_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput61 wdata[61] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__buf_1
Xinput50 wdata[51] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_1
Xinput72 wdata[71] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dlymetal6s2s_1
X_1866_ clknet_leaf_19_clk _0078_ VGND VGND VPWR VPWR mem\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1797_ clknet_leaf_22_clk _0009_ VGND VGND VPWR VPWR mem\[3\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_1935_ clknet_leaf_24_clk _0147_ VGND VGND VPWR VPWR mem\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_59_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold108 net123 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__dlygate4sd3_1
X_1720_ mem\[3\]\[51\] _0680_ _0716_ mem\[1\]\[51\] _0709_ VGND VGND VPWR VPWR _0737_
+ sky130_fd_sc_hd__a221o_1
X_1651_ net260 _0664_ _0686_ _0687_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__o22a_1
Xhold119 _0318_ VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__dlygate4sd3_1
X_1582_ net239 _0634_ _0635_ _0636_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__o22a_1
X_2134_ clknet_leaf_12_clk _0346_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dfxtp_1
X_2065_ clknet_leaf_11_clk _0277_ VGND VGND VPWR VPWR mem\[1\]\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1016_ net277 net55 _0843_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_14_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1918_ clknet_leaf_12_clk _0130_ VGND VGND VPWR VPWR mem\[0\]\[58\] sky130_fd_sc_hd__dfxtp_1
X_1849_ clknet_leaf_11_clk _0061_ VGND VGND VPWR VPWR mem\[3\]\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_20_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_49_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_11_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_11_clk sky130_fd_sc_hd__clkbuf_8
X_1703_ _0607_ _0608_ mem\[3\]\[46\] VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__and3_1
XFILLER_0_30_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1634_ mem\[0\]\[27\] _0651_ _0637_ mem\[1\]\[27\] VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__a22o_1
XFILLER_0_39_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1496_ net64 net346 _0567_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__mux2_1
X_1565_ mem\[3\]\[8\] _0599_ _0591_ mem\[2\]\[8\] _0624_ VGND VGND VPWR VPWR _0625_
+ sky130_fd_sc_hd__a221o_1
X_2117_ clknet_leaf_7_clk _0329_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2048_ clknet_leaf_3_clk _0260_ VGND VGND VPWR VPWR mem\[1\]\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1350_ _0493_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__clkbuf_1
X_1281_ _0457_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_0_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_25_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0996_ _0839_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
X_1617_ mem\[3\]\[23\] _0586_ _0637_ mem\[1\]\[23\] VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__a22o_1
X_1548_ _0785_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__buf_4
X_1479_ net55 net462 _0556_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_17_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold291 mem\[2\]\[16\] VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold280 mem\[0\]\[7\] VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_62_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1402_ _0522_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1333_ net60 net342 _0484_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__mux2_1
Xinput4 wdata[0] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
X_1264_ _0448_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__clkbuf_1
X_1195_ _0410_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_2_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_46_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0979_ _0830_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0902_ _0790_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1951_ clknet_leaf_27_clk _0163_ VGND VGND VPWR VPWR mem\[2\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_1882_ clknet_leaf_26_clk _0094_ VGND VGND VPWR VPWR mem\[0\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1178_ net60 net484 _0401_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__mux2_1
X_1316_ net51 net505 _0473_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1247_ _0439_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_45_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1032_ _0858_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__clkbuf_1
X_1101_ _0361_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__clkbuf_1
X_2081_ clknet_leaf_20_clk net162 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1934_ clknet_leaf_21_clk _0146_ VGND VGND VPWR VPWR mem\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput51 wdata[52] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_1
Xinput62 wdata[62] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_1
Xinput40 wdata[42] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_1
X_1865_ clknet_leaf_20_clk _0077_ VGND VGND VPWR VPWR mem\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_1796_ clknet_leaf_21_clk _0008_ VGND VGND VPWR VPWR mem\[3\]\[8\] sky130_fd_sc_hd__dfxtp_1
Xinput73 wdata[7] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__buf_1
XFILLER_0_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold109 _0339_ VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__dlygate4sd3_1
X_1581_ mem\[3\]\[13\] _0599_ _0591_ mem\[2\]\[13\] _0624_ VGND VGND VPWR VPWR _0636_
+ sky130_fd_sc_hd__a221o_1
X_1650_ mem\[3\]\[31\] _0680_ _0659_ mem\[1\]\[31\] _0670_ VGND VGND VPWR VPWR _0687_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2064_ clknet_leaf_13_clk _0276_ VGND VGND VPWR VPWR mem\[1\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_1015_ _0849_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
X_2133_ clknet_leaf_9_clk net253 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dfxtp_1
X_1917_ clknet_leaf_9_clk _0129_ VGND VGND VPWR VPWR mem\[0\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_1848_ clknet_leaf_13_clk _0060_ VGND VGND VPWR VPWR mem\[3\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_1779_ mem\[3\]\[69\] _0585_ _0619_ mem\[2\]\[69\] _0746_ VGND VGND VPWR VPWR _0778_
+ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_31_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1702_ mem\[2\]\[46\] _0597_ _0604_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__a21o_1
XFILLER_0_30_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1564_ _0593_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__clkbuf_4
X_1633_ net95 _0664_ _0673_ net244 VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__o22a_1
X_1495_ _0571_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__clkbuf_1
X_2047_ clknet_leaf_5_clk _0259_ VGND VGND VPWR VPWR mem\[1\]\[43\] sky130_fd_sc_hd__dfxtp_1
X_2116_ clknet_leaf_5_clk net184 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1280_ net32 net189 _0451_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__mux2_1
X_0995_ net274 net44 _0832_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1547_ _0784_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__buf_4
XFILLER_0_14_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1616_ net233 _0634_ _0658_ _0661_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__o22a_1
X_1478_ _0562_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_37_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold281 mem\[3\]\[57\] VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__dlygate4sd3_1
Xhold270 mem\[0\]\[3\] VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__dlygate4sd3_1
Xhold292 mem\[1\]\[6\] VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1401_ net14 net382 _0512_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1194_ net68 net477 _0401_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__mux2_1
X_1332_ _0417_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__clkbuf_4
X_1263_ net23 net444 _0440_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__mux2_1
Xinput5 wdata[10] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_34_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0978_ net300 net35 _0821_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_48_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1950_ clknet_leaf_24_clk _0162_ VGND VGND VPWR VPWR mem\[2\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0901_ net384 net15 _0788_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1881_ clknet_leaf_27_clk _0093_ VGND VGND VPWR VPWR mem\[0\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_1315_ _0475_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1177_ _0868_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__buf_4
X_1246_ net14 net480 _0429_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1031_ net308 net63 _0854_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__mux2_1
X_2080_ clknet_leaf_19_clk _0292_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dfxtp_1
X_1100_ net19 net494 _0891_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__mux2_1
X_1933_ clknet_leaf_16_clk _0145_ VGND VGND VPWR VPWR mem\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput52 wdata[53] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_1
Xinput63 wdata[63] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_1
Xinput41 wdata[43] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_1
X_1864_ clknet_leaf_19_clk _0076_ VGND VGND VPWR VPWR mem\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
Xinput30 wdata[33] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_1
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput74 wdata[8] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__buf_1
X_1795_ clknet_leaf_21_clk _0007_ VGND VGND VPWR VPWR mem\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_1229_ _0430_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_44_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1580_ mem\[0\]\[13\] _0596_ _0587_ mem\[1\]\[13\] VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_53_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2132_ clknet_leaf_18_clk net255 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2063_ clknet_leaf_8_clk _0275_ VGND VGND VPWR VPWR mem\[1\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_1014_ net307 net54 _0843_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_62_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1847_ clknet_leaf_8_clk _0059_ VGND VGND VPWR VPWR mem\[3\]\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1916_ clknet_leaf_17_clk _0128_ VGND VGND VPWR VPWR mem\[0\]\[56\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1778_ mem\[0\]\[69\] _0590_ _0600_ mem\[1\]\[69\] VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__a22o_1
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1701_ net227 _0695_ _0722_ _0723_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__o22a_1
XFILLER_0_41_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1494_ net63 net393 _0567_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1563_ mem\[0\]\[8\] _0596_ _0587_ mem\[1\]\[8\] VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__a22o_1
X_1632_ net243 _0669_ _0659_ mem\[1\]\[26\] _0670_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__a221o_1
X_2115_ clknet_leaf_3_clk net226 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dfxtp_1
X_2046_ clknet_leaf_5_clk _0258_ VGND VGND VPWR VPWR mem\[1\]\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0994_ _0838_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1477_ net54 net334 _0556_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__mux2_1
X_1546_ net187 _0583_ _0605_ _0610_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__o22a_1
X_1615_ mem\[0\]\[22\] _0606_ _0659_ mem\[1\]\[22\] _0660_ VGND VGND VPWR VPWR _0661_
+ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_37_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2029_ clknet_leaf_29_clk _0241_ VGND VGND VPWR VPWR mem\[1\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold260 mem\[1\]\[20\] VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__dlygate4sd3_1
Xhold271 mem\[2\]\[2\] VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_20_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold293 mem\[2\]\[8\] VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__dlygate4sd3_1
Xhold282 mem\[1\]\[25\] VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1331_ _0483_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__clkbuf_1
X_1400_ _0521_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__clkbuf_1
X_1193_ _0409_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__clkbuf_1
Xinput6 wdata[11] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
X_1262_ _0447_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_34_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0977_ _0829_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1529_ _0589_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0900_ _0789_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_1
X_1880_ clknet_leaf_28_clk _0092_ VGND VGND VPWR VPWR mem\[0\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1314_ net50 net513 _0473_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1176_ _0400_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1245_ _0438_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput140 net140 VGND VGND VPWR VPWR rdata[67] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1030_ _0857_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1932_ clknet_leaf_16_clk _0144_ VGND VGND VPWR VPWR mem\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xinput20 wdata[24] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_1
X_1863_ clknet_leaf_22_clk _0075_ VGND VGND VPWR VPWR mem\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
Xinput31 wdata[34] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
Xinput53 wdata[54] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_58_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput42 wdata[44] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_1
Xinput64 wdata[64] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_1
X_1794_ clknet_leaf_19_clk _0006_ VGND VGND VPWR VPWR mem\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xinput75 wdata[9] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__buf_1
XFILLER_0_58_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1228_ net5 net475 _0429_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__mux2_1
X_1159_ net50 net456 _0390_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_23_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_23_clk sky130_fd_sc_hd__clkbuf_8
X_2062_ clknet_leaf_12_clk _0274_ VGND VGND VPWR VPWR mem\[1\]\[58\] sky130_fd_sc_hd__dfxtp_1
X_2131_ clknet_leaf_11_clk net198 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dfxtp_1
X_1013_ _0848_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1846_ clknet_leaf_8_clk _0058_ VGND VGND VPWR VPWR mem\[3\]\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1915_ clknet_leaf_12_clk _0127_ VGND VGND VPWR VPWR mem\[0\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_1777_ net151 _0757_ _0775_ _0776_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__o22a_1
Xclkbuf_leaf_14_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1700_ mem\[3\]\[45\] _0680_ _0706_ mem\[2\]\[45\] _0709_ VGND VGND VPWR VPWR _0723_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_26_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1631_ mem\[3\]\[26\] _0672_ _0617_ mem\[0\]\[26\] VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__a22o_1
X_1493_ _0570_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_3_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_39_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1562_ net203 _0583_ _0621_ _0622_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__o22a_1
XFILLER_0_55_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2045_ clknet_leaf_7_clk _0257_ VGND VGND VPWR VPWR mem\[1\]\[41\] sky130_fd_sc_hd__dfxtp_1
X_2114_ clknet_leaf_4_clk _0326_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1829_ clknet_leaf_7_clk _0041_ VGND VGND VPWR VPWR mem\[3\]\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0993_ net448 net43 _0832_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1614_ _0607_ _0608_ mem\[3\]\[22\] VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__and3_1
X_1476_ _0561_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1545_ mem\[0\]\[3\] _0606_ _0600_ mem\[1\]\[3\] _0609_ VGND VGND VPWR VPWR _0610_
+ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_37_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2028_ clknet_leaf_26_clk _0240_ VGND VGND VPWR VPWR mem\[1\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold261 mem\[2\]\[62\] VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold250 mem\[1\]\[54\] VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_32_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold272 mem\[1\]\[16\] VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_20_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold294 mem\[0\]\[34\] VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__dlygate4sd3_1
Xhold283 mem\[0\]\[36\] VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1330_ net58 net412 _0473_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__mux2_1
X_1261_ net22 net243 _0440_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__mux2_1
X_1192_ net67 net296 _0401_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput7 wdata[12] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_34_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0976_ net323 net34 _0821_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1459_ _0552_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__clkbuf_1
X_1528_ net262 _0583_ _0588_ _0595_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__o22a_1
XFILLER_0_20_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1313_ _0474_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__clkbuf_1
X_1244_ net13 net552 _0429_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__mux2_1
X_1175_ net58 net381 _0390_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0959_ net330 net25 _0810_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__mux2_1
Xoutput130 net130 VGND VGND VPWR VPWR rdata[58] sky130_fd_sc_hd__clkbuf_4
Xoutput141 net141 VGND VGND VPWR VPWR rdata[68] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_6_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput54 wdata[55] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_1
XFILLER_0_56_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput43 wdata[45] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__buf_1
Xinput32 wdata[35] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__dlymetal6s2s_1
X_1931_ clknet_leaf_18_clk _0143_ VGND VGND VPWR VPWR mem\[0\]\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput21 wdata[25] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__buf_1
Xinput10 wdata[15] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_1
X_1862_ clknet_leaf_21_clk _0074_ VGND VGND VPWR VPWR mem\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_1793_ clknet_leaf_20_clk _0005_ VGND VGND VPWR VPWR mem\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput65 wdata[65] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_1
Xinput76 wr_n VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__clkbuf_2
X_1158_ _0391_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__clkbuf_1
X_1227_ _0417_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__buf_4
X_1089_ net13 net562 _0880_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2061_ clknet_leaf_9_clk _0273_ VGND VGND VPWR VPWR mem\[1\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_1012_ net269 net53 _0843_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__mux2_1
X_2130_ clknet_leaf_10_clk net458 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1914_ clknet_leaf_10_clk _0126_ VGND VGND VPWR VPWR mem\[0\]\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1776_ mem\[3\]\[68\] _0585_ _0619_ mem\[2\]\[68\] _0746_ VGND VGND VPWR VPWR _0776_
+ sky130_fd_sc_hd__a221o_1
X_1845_ clknet_leaf_9_clk _0057_ VGND VGND VPWR VPWR mem\[3\]\[57\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_9_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1630_ _0585_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__buf_4
XFILLER_0_30_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1492_ net62 net410 _0567_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__mux2_1
X_1561_ mem\[0\]\[7\] _0606_ _0591_ mem\[2\]\[7\] _0594_ VGND VGND VPWR VPWR _0622_
+ sky130_fd_sc_hd__a221o_1
X_2044_ clknet_leaf_4_clk _0256_ VGND VGND VPWR VPWR mem\[1\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_2113_ clknet_leaf_1_clk net236 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1828_ clknet_leaf_5_clk _0040_ VGND VGND VPWR VPWR mem\[3\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_1759_ mem\[0\]\[63\] _0590_ _0591_ mem\[2\]\[63\] VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__a22o_1
Xhold410 mem\[0\]\[32\] VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_35_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0992_ _0837_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__clkbuf_1
X_1613_ _0498_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1544_ _0607_ _0608_ mem\[3\]\[3\] VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__and3_1
X_1475_ net53 net398 _0556_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_59_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2027_ clknet_leaf_27_clk _0239_ VGND VGND VPWR VPWR mem\[1\]\[23\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_20_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold262 mem\[1\]\[62\] VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__dlygate4sd3_1
Xhold240 mem\[1\]\[68\] VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__dlygate4sd3_1
Xhold295 mem\[1\]\[61\] VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__dlygate4sd3_1
Xhold284 mem\[1\]\[1\] VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__dlygate4sd3_1
Xhold273 mem\[3\]\[0\] VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__dlygate4sd3_1
Xhold251 mem\[2\]\[29\] VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1191_ _0408_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__clkbuf_1
Xinput8 wdata[13] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_1
X_1260_ _0446_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0975_ _0828_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__clkbuf_1
X_1527_ mem\[0\]\[0\] _0590_ _0591_ mem\[2\]\[0\] _0594_ VGND VGND VPWR VPWR _0595_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_10_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1458_ net44 net556 _0545_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__mux2_1
X_1389_ net8 net481 _0512_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1174_ _0399_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__clkbuf_1
X_1312_ net49 net553 _0473_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_47_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1243_ _0437_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_22_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0958_ _0819_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
Xoutput131 net131 VGND VGND VPWR VPWR rdata[59] sky130_fd_sc_hd__clkbuf_4
Xoutput120 net120 VGND VGND VPWR VPWR rdata[49] sky130_fd_sc_hd__buf_2
Xoutput142 net142 VGND VGND VPWR VPWR rdata[69] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_18_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1930_ clknet_leaf_17_clk _0142_ VGND VGND VPWR VPWR mem\[0\]\[70\] sky130_fd_sc_hd__dfxtp_1
Xinput44 wdata[46] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_1
Xinput66 wdata[66] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__buf_1
Xinput55 wdata[56] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__dlymetal6s2s_1
X_1861_ clknet_leaf_16_clk _0073_ VGND VGND VPWR VPWR mem\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_1792_ clknet_leaf_18_clk _0004_ VGND VGND VPWR VPWR mem\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput11 wdata[16] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_1
Xinput22 wdata[26] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__buf_1
Xinput33 wdata[36] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_1
XFILLER_0_58_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1157_ net49 net453 _0390_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__mux2_1
X_1226_ _0428_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1088_ _0888_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_58_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1011_ _0847_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2060_ clknet_leaf_18_clk _0272_ VGND VGND VPWR VPWR mem\[1\]\[56\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1913_ clknet_leaf_12_clk _0125_ VGND VGND VPWR VPWR mem\[0\]\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1775_ mem\[0\]\[68\] _0590_ _0721_ mem\[1\]\[68\] VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__a22o_1
X_1844_ clknet_leaf_10_clk _0056_ VGND VGND VPWR VPWR mem\[3\]\[56\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_40_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1209_ net15 net389 _0418_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1560_ mem\[3\]\[7\] _0586_ _0587_ mem\[1\]\[7\] VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__a22o_1
XFILLER_0_55_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1491_ _0569_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__clkbuf_1
X_2112_ clknet_leaf_0_clk net249 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dfxtp_1
X_2043_ clknet_leaf_4_clk _0255_ VGND VGND VPWR VPWR mem\[1\]\[39\] sky130_fd_sc_hd__dfxtp_1
X_1827_ clknet_leaf_4_clk _0039_ VGND VGND VPWR VPWR mem\[3\]\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1758_ net175 _0757_ _0762_ _0763_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__o22a_1
Xhold400 mem\[0\]\[43\] VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__dlygate4sd3_1
X_1689_ net207 _0695_ _0713_ _0714_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__o22a_1
Xhold411 mem\[1\]\[37\] VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0991_ net280 net42 _0832_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1474_ _0560_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__clkbuf_1
X_1543_ _0785_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__clkbuf_4
X_1612_ mem\[2\]\[22\] _0597_ _0604_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__a21o_1
XFILLER_0_57_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2026_ clknet_leaf_25_clk _0238_ VGND VGND VPWR VPWR mem\[1\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold252 mem\[2\]\[66\] VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__dlygate4sd3_1
Xhold263 mem\[1\]\[65\] VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__dlygate4sd3_1
Xhold285 net103 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__dlygate4sd3_1
Xhold241 mem\[2\]\[1\] VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__dlygate4sd3_1
Xhold296 mem\[2\]\[27\] VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__dlygate4sd3_1
Xhold230 mem\[3\]\[20\] VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__dlygate4sd3_1
Xhold274 mem\[1\]\[22\] VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__dlygate4sd3_1
X_1190_ net66 net354 _0401_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__mux2_1
XFILLER_0_36_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput9 wdata[14] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
XFILLER_0_46_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0974_ net339 net33 _0821_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__mux2_1
X_1457_ _0551_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1526_ _0593_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__clkbuf_4
X_1388_ _0515_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__clkbuf_1
X_2009_ clknet_leaf_20_clk _0221_ VGND VGND VPWR VPWR mem\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1311_ _0417_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__buf_4
XFILLER_0_11_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1173_ net57 net362 _0390_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_47_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1242_ net12 net312 _0429_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_30_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput121 net121 VGND VGND VPWR VPWR rdata[4] sky130_fd_sc_hd__buf_2
XFILLER_0_27_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput110 net110 VGND VGND VPWR VPWR rdata[3] sky130_fd_sc_hd__clkbuf_4
X_0957_ net360 net24 _0810_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__mux2_1
Xoutput132 net132 VGND VGND VPWR VPWR rdata[5] sky130_fd_sc_hd__clkbuf_4
Xoutput143 net143 VGND VGND VPWR VPWR rdata[6] sky130_fd_sc_hd__clkbuf_4
X_1509_ _0578_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_53_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1860_ clknet_leaf_16_clk _0072_ VGND VGND VPWR VPWR mem\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_26_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_26_clk sky130_fd_sc_hd__clkbuf_8
Xinput67 wdata[67] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__buf_1
Xinput56 wdata[57] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_1
Xinput45 wdata[47] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__buf_1
Xinput34 wdata[37] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_1
Xinput23 wdata[27] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_1
Xinput12 wdata[17] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_1
X_1791_ clknet_leaf_24_clk _0003_ VGND VGND VPWR VPWR mem\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_17_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_8
X_1156_ _0868_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__buf_4
X_1225_ net75 net344 _0418_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__mux2_1
X_1087_ net12 net460 _0880_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1989_ clknet_leaf_9_clk _0201_ VGND VGND VPWR VPWR mem\[2\]\[57\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_23_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1010_ net282 net52 _0843_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__mux2_1
X_1912_ clknet_leaf_8_clk _0124_ VGND VGND VPWR VPWR mem\[0\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_1843_ clknet_leaf_11_clk _0055_ VGND VGND VPWR VPWR mem\[3\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_1774_ _0774_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_6_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_8_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1208_ _0419_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__clkbuf_1
X_1139_ _0381_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1490_ net61 net443 _0567_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2042_ clknet_leaf_4_clk _0254_ VGND VGND VPWR VPWR mem\[1\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_2111_ clknet_leaf_9_clk net190 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dfxtp_1
Xhold1 net147 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1826_ clknet_leaf_4_clk _0038_ VGND VGND VPWR VPWR mem\[3\]\[38\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold401 mem\[2\]\[31\] VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__dlygate4sd3_1
X_1757_ mem\[3\]\[62\] _0585_ _0619_ mem\[2\]\[62\] _0746_ VGND VGND VPWR VPWR _0763_
+ sky130_fd_sc_hd__a221o_1
X_1688_ mem\[2\]\[42\] _0669_ _0659_ mem\[1\]\[42\] _0709_ VGND VGND VPWR VPWR _0714_
+ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold412 mem\[1\]\[31\] VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_0_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0990_ _0836_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
X_1611_ net181 _0634_ _0656_ _0657_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__o22a_1
X_1473_ net52 net356 _0556_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__mux2_1
X_1542_ _0784_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__buf_2
X_2025_ clknet_leaf_27_clk _0237_ VGND VGND VPWR VPWR mem\[1\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold220 mem\[2\]\[55\] VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__dlygate4sd3_1
Xhold242 mem\[2\]\[38\] VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_32_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold231 mem\[1\]\[4\] VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__dlygate4sd3_1
X_1809_ clknet_leaf_28_clk _0021_ VGND VGND VPWR VPWR mem\[3\]\[21\] sky130_fd_sc_hd__dfxtp_1
Xhold253 mem\[1\]\[26\] VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__dlygate4sd3_1
Xhold264 mem\[2\]\[59\] VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__dlygate4sd3_1
Xhold297 mem\[1\]\[50\] VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__dlygate4sd3_1
Xhold275 mem\[2\]\[71\] VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__dlygate4sd3_1
Xhold286 mem\[2\]\[13\] VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0973_ _0827_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1456_ net43 net546 _0545_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__mux2_1
X_1525_ _0592_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__buf_2
X_1387_ net7 net395 _0512_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__mux2_1
X_2008_ clknet_leaf_18_clk _0220_ VGND VGND VPWR VPWR mem\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_33_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1310_ _0472_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1241_ _0436_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_47_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1172_ _0398_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0956_ _0818_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
Xoutput122 net122 VGND VGND VPWR VPWR rdata[50] sky130_fd_sc_hd__clkbuf_4
Xoutput133 net133 VGND VGND VPWR VPWR rdata[60] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput111 net111 VGND VGND VPWR VPWR rdata[40] sky130_fd_sc_hd__clkbuf_4
Xoutput144 net144 VGND VGND VPWR VPWR rdata[70] sky130_fd_sc_hd__buf_2
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput100 net100 VGND VGND VPWR VPWR rdata[30] sky130_fd_sc_hd__clkbuf_4
X_1508_ net71 net466 _0500_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__mux2_1
X_1439_ net34 net559 _0534_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_53_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput13 wdata[18] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_1
X_1790_ clknet_leaf_20_clk _0002_ VGND VGND VPWR VPWR mem\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xinput57 wdata[58] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__buf_1
Xinput68 wdata[68] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__buf_1
Xinput46 wdata[48] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_1
Xinput35 wdata[38] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_1
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput24 wdata[28] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
X_1224_ _0427_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__clkbuf_1
X_1155_ _0389_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__clkbuf_1
X_1086_ _0887_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_50_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1988_ clknet_leaf_10_clk _0200_ VGND VGND VPWR VPWR mem\[2\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_0939_ _0809_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_2_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_53_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1773_ net501 _0773_ _0581_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1911_ clknet_leaf_10_clk _0123_ VGND VGND VPWR VPWR mem\[0\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_1842_ clknet_leaf_10_clk _0054_ VGND VGND VPWR VPWR mem\[3\]\[54\] sky130_fd_sc_hd__dfxtp_1
X_1207_ net4 net426 _0418_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__mux2_1
X_1138_ net39 net348 _0379_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1069_ _0878_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2041_ clknet_leaf_1_clk _0253_ VGND VGND VPWR VPWR mem\[1\]\[37\] sky130_fd_sc_hd__dfxtp_1
Xhold2 _0296_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dlygate4sd3_1
X_2110_ clknet_leaf_30_clk net174 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold402 mem\[1\]\[60\] VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__dlygate4sd3_1
X_1756_ mem\[0\]\[62\] _0590_ _0721_ mem\[1\]\[62\] VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__a22o_1
Xhold413 mem\[1\]\[52\] VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__dlygate4sd3_1
X_1825_ clknet_leaf_0_clk _0037_ VGND VGND VPWR VPWR mem\[3\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_1687_ mem\[3\]\[42\] _0672_ _0617_ mem\[0\]\[42\] VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_0_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1610_ mem\[0\]\[21\] _0606_ _0600_ mem\[1\]\[21\] _0624_ VGND VGND VPWR VPWR _0657_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1472_ _0559_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1541_ _0589_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_49_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2024_ clknet_leaf_26_clk _0236_ VGND VGND VPWR VPWR mem\[1\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold232 mem\[0\]\[53\] VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__dlygate4sd3_1
Xhold221 mem\[0\]\[63\] VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold265 mem\[2\]\[65\] VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__dlygate4sd3_1
Xhold210 mem\[0\]\[69\] VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__dlygate4sd3_1
X_1739_ net254 _0727_ _0748_ _0750_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__o22a_1
XFILLER_0_32_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold287 mem\[0\]\[16\] VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__dlygate4sd3_1
Xhold243 mem\[1\]\[29\] VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__dlygate4sd3_1
X_1808_ clknet_leaf_28_clk _0020_ VGND VGND VPWR VPWR mem\[3\]\[20\] sky130_fd_sc_hd__dfxtp_1
Xhold254 mem\[0\]\[2\] VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold276 mem\[0\]\[26\] VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_37_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold298 mem\[1\]\[8\] VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_36_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0972_ net279 net32 _0821_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1524_ net3 net76 VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__or2b_1
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1455_ _0550_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__clkbuf_1
X_1386_ _0514_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2007_ clknet_leaf_24_clk _0219_ VGND VGND VPWR VPWR mem\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_33_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1171_ net56 net555 _0390_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__mux2_1
X_1240_ net11 net439 _0429_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_47_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0955_ net318 net23 _0810_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__mux2_1
Xoutput123 net123 VGND VGND VPWR VPWR rdata[51] sky130_fd_sc_hd__clkbuf_4
Xoutput112 net112 VGND VGND VPWR VPWR rdata[41] sky130_fd_sc_hd__clkbuf_4
Xoutput134 net134 VGND VGND VPWR VPWR rdata[61] sky130_fd_sc_hd__buf_2
X_1507_ _0577_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__clkbuf_1
Xoutput145 net145 VGND VGND VPWR VPWR rdata[71] sky130_fd_sc_hd__clkbuf_4
Xoutput101 net101 VGND VGND VPWR VPWR rdata[31] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1369_ _0505_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__clkbuf_1
X_1438_ _0541_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_53_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput36 wdata[39] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_26_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput25 wdata[29] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_1
Xinput14 wdata[19] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_1
Xinput58 wdata[59] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__buf_1
Xinput47 wdata[49] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__buf_1
Xinput69 wdata[69] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__buf_1
X_1154_ net47 net509 _0379_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__mux2_1
X_1223_ net74 net441 _0418_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__mux2_1
X_1085_ net11 net435 _0880_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__mux2_1
X_1987_ clknet_leaf_11_clk _0199_ VGND VGND VPWR VPWR mem\[2\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_0938_ net335 net14 _0799_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1910_ clknet_leaf_12_clk _0122_ VGND VGND VPWR VPWR mem\[0\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_1841_ clknet_leaf_12_clk _0053_ VGND VGND VPWR VPWR mem\[3\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_1772_ mem\[0\]\[67\] mem\[1\]\[67\] mem\[2\]\[67\] mem\[3\]\[67\] _0784_ _0608_
+ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__mux4_1
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1137_ _0380_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__clkbuf_1
X_1206_ _0417_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__buf_4
XFILLER_0_47_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1068_ net74 net452 _0869_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_3_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold3 net141 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dlygate4sd3_1
X_2040_ clknet_leaf_0_clk _0252_ VGND VGND VPWR VPWR mem\[1\]\[36\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1686_ _0712_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__clkbuf_1
X_1755_ net231 _0757_ _0760_ _0761_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__o22a_1
Xhold403 mem\[0\]\[46\] VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_29_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold414 mem\[0\]\[18\] VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__dlygate4sd3_1
X_1824_ clknet_leaf_0_clk _0036_ VGND VGND VPWR VPWR mem\[3\]\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_13_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1540_ mem\[2\]\[3\] _0597_ _0604_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1471_ net51 net561 _0556_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2023_ clknet_leaf_27_clk _0235_ VGND VGND VPWR VPWR mem\[1\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1807_ clknet_leaf_27_clk _0019_ VGND VGND VPWR VPWR mem\[3\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold244 mem\[2\]\[53\] VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__dlygate4sd3_1
Xhold233 mem\[0\]\[59\] VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__dlygate4sd3_1
Xhold200 mem\[0\]\[41\] VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__dlygate4sd3_1
Xhold222 mem\[0\]\[48\] VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__dlygate4sd3_1
Xhold277 mem\[3\]\[43\] VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__dlygate4sd3_1
X_1738_ mem\[0\]\[56\] _0683_ _0706_ mem\[2\]\[56\] _0749_ VGND VGND VPWR VPWR _0750_
+ sky130_fd_sc_hd__a221o_1
Xhold299 mem\[0\]\[37\] VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__dlygate4sd3_1
X_1669_ net248 _0695_ _0699_ _0700_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__o22a_1
Xhold288 mem\[2\]\[36\] VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold266 mem\[0\]\[19\] VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__dlygate4sd3_1
Xhold211 mem\[0\]\[24\] VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__dlygate4sd3_1
Xhold255 mem\[2\]\[15\] VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0971_ _0826_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
X_1454_ net42 net351 _0545_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__mux2_1
X_1523_ _0415_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__buf_4
X_1385_ net6 net387 _0512_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_33_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2006_ clknet_leaf_20_clk _0218_ VGND VGND VPWR VPWR mem\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_56_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1170_ _0397_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_56_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_29_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_29_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_42_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0954_ _0817_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
Xoutput124 net124 VGND VGND VPWR VPWR rdata[52] sky130_fd_sc_hd__clkbuf_4
Xoutput135 net135 VGND VGND VPWR VPWR rdata[62] sky130_fd_sc_hd__buf_2
Xoutput113 net113 VGND VGND VPWR VPWR rdata[42] sky130_fd_sc_hd__clkbuf_4
X_1506_ net69 net396 _0567_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__mux2_1
X_1437_ net33 net507 _0534_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput102 net102 VGND VGND VPWR VPWR rdata[32] sky130_fd_sc_hd__clkbuf_4
Xoutput146 net146 VGND VGND VPWR VPWR rdata[7] sky130_fd_sc_hd__buf_2
X_1299_ net42 net363 _0462_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1368_ net37 net540 _0501_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput15 wdata[1] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_1
Xinput37 wdata[3] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_1
Xinput48 wdata[4] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput26 wdata[2] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_1
Xinput59 wdata[5] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_9_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1153_ _0388_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1084_ _0886_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__clkbuf_1
X_1222_ _0426_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__clkbuf_1
X_1986_ clknet_leaf_9_clk _0198_ VGND VGND VPWR VPWR mem\[2\]\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_61_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_9_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_30_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0937_ _0808_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1840_ clknet_leaf_8_clk _0052_ VGND VGND VPWR VPWR mem\[3\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_1771_ net155 _0757_ _0771_ _0772_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__o22a_1
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1136_ net38 net508 _0379_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__mux2_1
X_1205_ _0416_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__clkbuf_4
X_1067_ _0877_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_34_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1969_ clknet_leaf_1_clk _0181_ VGND VGND VPWR VPWR mem\[2\]\[37\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_3_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold4 _0356_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_39_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1823_ clknet_leaf_3_clk _0035_ VGND VGND VPWR VPWR mem\[3\]\[35\] sky130_fd_sc_hd__dfxtp_1
X_1685_ net504 _0711_ _0581_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__mux2_1
X_1754_ mem\[0\]\[61\] _0683_ _0706_ mem\[2\]\[61\] _0746_ VGND VGND VPWR VPWR _0761_
+ sky130_fd_sc_hd__a221o_1
Xhold415 net121 VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold404 mem\[2\]\[18\] VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_45_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1119_ net29 net558 _0368_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__mux2_1
X_2099_ clknet_leaf_27_clk net158 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_39_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1470_ _0558_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_30_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2022_ clknet_leaf_24_clk _0234_ VGND VGND VPWR VPWR mem\[1\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1806_ clknet_leaf_24_clk _0018_ VGND VGND VPWR VPWR mem\[3\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xhold201 mem\[3\]\[34\] VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold256 mem\[3\]\[60\] VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__dlygate4sd3_1
Xhold223 mem\[3\]\[66\] VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__dlygate4sd3_1
Xhold245 mem\[1\]\[63\] VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__dlygate4sd3_1
Xhold267 mem\[0\]\[54\] VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__dlygate4sd3_1
X_1737_ _0611_ _0785_ mem\[3\]\[56\] VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__and3_1
Xhold278 mem\[2\]\[0\] VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__dlygate4sd3_1
Xhold289 mem\[2\]\[39\] VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__dlygate4sd3_1
X_1668_ mem\[3\]\[36\] _0680_ _0639_ mem\[2\]\[36\] _0670_ VGND VGND VPWR VPWR _0700_
+ sky130_fd_sc_hd__a221o_1
Xhold234 mem\[1\]\[19\] VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__dlygate4sd3_1
Xhold212 mem\[3\]\[28\] VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__dlygate4sd3_1
X_1599_ _0607_ _0608_ mem\[3\]\[18\] VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_28_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0970_ net349 net31 _0821_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__mux2_1
X_1453_ _0549_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__clkbuf_1
X_1522_ _0589_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__buf_4
X_2005_ clknet_leaf_19_clk _0217_ VGND VGND VPWR VPWR mem\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_1384_ _0513_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput114 net114 VGND VGND VPWR VPWR rdata[43] sky130_fd_sc_hd__clkbuf_4
Xoutput125 net125 VGND VGND VPWR VPWR rdata[53] sky130_fd_sc_hd__clkbuf_4
Xoutput103 net103 VGND VGND VPWR VPWR rdata[33] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0953_ net295 net22 _0810_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__mux2_1
X_1505_ _0576_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__clkbuf_1
Xoutput136 net136 VGND VGND VPWR VPWR rdata[63] sky130_fd_sc_hd__buf_2
X_1436_ _0540_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__clkbuf_1
Xoutput147 net147 VGND VGND VPWR VPWR rdata[8] sky130_fd_sc_hd__buf_2
X_1367_ _0504_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__clkbuf_1
X_1298_ _0466_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput49 wdata[50] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_1
Xinput38 wdata[40] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_1
Xinput27 wdata[30] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_1
Xinput16 wdata[20] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_1
XFILLER_0_58_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1221_ net73 net479 _0418_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1152_ net46 net370 _0379_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__mux2_1
X_1083_ net10 net525 _0880_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1985_ clknet_leaf_12_clk _0197_ VGND VGND VPWR VPWR mem\[2\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_0936_ net309 net13 _0799_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__mux2_1
X_1419_ _0531_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1770_ mem\[3\]\[66\] _0585_ _0619_ mem\[2\]\[66\] _0746_ VGND VGND VPWR VPWR _0772_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_40_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1204_ net3 net76 _0415_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__or3b_1
X_1135_ _0868_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__buf_4
XFILLER_0_19_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1066_ net73 net428 _0869_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1899_ clknet_leaf_1_clk _0111_ VGND VGND VPWR VPWR mem\[0\]\[39\] sky130_fd_sc_hd__dfxtp_1
X_1968_ clknet_leaf_0_clk _0180_ VGND VGND VPWR VPWR mem\[2\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_0919_ _0787_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_3_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold5 net142 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_17_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1753_ mem\[3\]\[61\] _0672_ _0721_ mem\[1\]\[61\] VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__a22o_1
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1822_ clknet_leaf_30_clk _0034_ VGND VGND VPWR VPWR mem\[3\]\[34\] sky130_fd_sc_hd__dfxtp_1
X_1684_ mem\[0\]\[41\] mem\[1\]\[41\] mem\[2\]\[41\] mem\[3\]\[41\] _0784_ _0612_
+ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__mux4_1
XFILLER_0_52_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold405 mem\[2\]\[50\] VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__dlygate4sd3_1
Xhold416 mem\[2\]\[47\] VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_29_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1049_ net1 net2 net3 net76 VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__or4_1
X_1118_ _0370_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__clkbuf_1
X_2098_ clknet_leaf_25_clk net234 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2021_ clknet_leaf_25_clk _0233_ VGND VGND VPWR VPWR mem\[1\]\[17\] sky130_fd_sc_hd__dfxtp_1
Xhold224 mem\[3\]\[40\] VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__dlygate4sd3_1
Xhold235 mem\[0\]\[56\] VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold202 mem\[3\]\[42\] VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__dlygate4sd3_1
X_1736_ mem\[1\]\[56\] _0587_ _0594_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__a21o_1
XFILLER_0_25_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold213 mem\[0\]\[12\] VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__dlygate4sd3_1
X_1805_ clknet_leaf_25_clk _0017_ VGND VGND VPWR VPWR mem\[3\]\[17\] sky130_fd_sc_hd__dfxtp_1
Xhold257 mem\[0\]\[55\] VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__dlygate4sd3_1
Xhold279 mem\[2\]\[56\] VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold268 mem\[0\]\[70\] VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__dlygate4sd3_1
Xhold246 mem\[0\]\[10\] VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__dlygate4sd3_1
X_1598_ mem\[1\]\[18\] _0587_ _0604_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__a21o_1
X_1667_ mem\[0\]\[36\] _0651_ _0637_ mem\[1\]\[36\] VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_28_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1452_ net41 net542 _0545_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__mux2_1
X_1521_ _0784_ _0785_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__nor2_2
X_1383_ net5 net463 _0512_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__mux2_1
X_2004_ clknet_leaf_20_clk _0216_ VGND VGND VPWR VPWR mem\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1719_ mem\[0\]\[51\] _0590_ _0591_ mem\[2\]\[51\] VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0952_ _0816_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
Xoutput126 net126 VGND VGND VPWR VPWR rdata[54] sky130_fd_sc_hd__buf_2
X_1504_ net68 net388 _0567_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__mux2_1
Xoutput137 net137 VGND VGND VPWR VPWR rdata[64] sky130_fd_sc_hd__buf_2
Xoutput115 net115 VGND VGND VPWR VPWR rdata[44] sky130_fd_sc_hd__clkbuf_4
Xoutput148 net148 VGND VGND VPWR VPWR rdata[9] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput104 net104 VGND VGND VPWR VPWR rdata[34] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_49_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1435_ net32 net407 _0534_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__mux2_1
X_1366_ net26 net518 _0501_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__mux2_1
X_1297_ net41 net524 _0462_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput39 wdata[41] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_1
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput17 wdata[21] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
Xinput28 wdata[31] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_1
X_1151_ _0387_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_9_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1220_ _0425_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1082_ _0885_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__clkbuf_1
X_1984_ clknet_leaf_9_clk _0196_ VGND VGND VPWR VPWR mem\[2\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_0935_ _0807_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1349_ net68 net478 _0484_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__mux2_1
X_1418_ net23 net493 _0523_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1134_ _0378_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__clkbuf_1
X_1203_ _0414_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_18_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1065_ _0876_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1967_ clknet_leaf_2_clk _0179_ VGND VGND VPWR VPWR mem\[2\]\[35\] sky130_fd_sc_hd__dfxtp_1
X_1898_ clknet_leaf_4_clk _0110_ VGND VGND VPWR VPWR mem\[0\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_0918_ _0798_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold6 _0357_ VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_60_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1752_ net229 _0757_ _0758_ _0759_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__o22a_1
X_1683_ net183 _0695_ _0708_ _0710_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__o22a_1
Xclkbuf_leaf_10_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_8
X_1821_ clknet_leaf_4_clk _0033_ VGND VGND VPWR VPWR mem\[3\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_25_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold406 mem\[2\]\[21\] VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__dlygate4sd3_1
Xhold417 net80 VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2097_ clknet_leaf_27_clk net182 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfxtp_1
X_1117_ net28 net530 _0368_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1048_ _0866_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2020_ clknet_leaf_23_clk _0232_ VGND VGND VPWR VPWR mem\[1\]\[16\] sky130_fd_sc_hd__dfxtp_1
Xhold214 mem\[0\]\[58\] VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__dlygate4sd3_1
X_1735_ net197 _0727_ _0745_ _0747_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__o22a_1
Xhold258 mem\[1\]\[66\] VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__dlygate4sd3_1
Xhold203 mem\[1\]\[44\] VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold225 mem\[0\]\[44\] VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__dlygate4sd3_1
X_1666_ net105 _0695_ _0696_ _0698_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__o22a_1
Xhold236 mem\[3\]\[1\] VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__dlygate4sd3_1
X_1804_ clknet_leaf_23_clk _0016_ VGND VGND VPWR VPWR mem\[3\]\[16\] sky130_fd_sc_hd__dfxtp_1
Xhold269 mem\[2\]\[24\] VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold247 mem\[1\]\[12\] VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_56_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1597_ _0647_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1520_ mem\[3\]\[0\] _0586_ _0587_ mem\[1\]\[0\] VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__a22o_1
X_1451_ _0548_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__clkbuf_1
X_1382_ _0500_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__buf_4
X_2003_ clknet_leaf_25_clk _0215_ VGND VGND VPWR VPWR mem\[2\]\[71\] sky130_fd_sc_hd__dfxtp_1
X_1718_ net201 _0727_ _0734_ _0735_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__o22a_1
X_1649_ mem\[0\]\[31\] _0651_ _0591_ mem\[2\]\[31\] VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__a22o_1
XFILLER_0_13_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0951_ net514 net21 _0810_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__mux2_1
Xoutput127 net127 VGND VGND VPWR VPWR rdata[55] sky130_fd_sc_hd__clkbuf_4
X_1503_ _0575_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__clkbuf_1
Xoutput105 net105 VGND VGND VPWR VPWR rdata[35] sky130_fd_sc_hd__clkbuf_4
Xoutput116 net116 VGND VGND VPWR VPWR rdata[45] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_42_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput138 net138 VGND VGND VPWR VPWR rdata[65] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1296_ _0465_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1365_ _0503_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__clkbuf_1
X_1434_ _0539_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_43_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_52_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_61_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput18 wdata[22] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_1
Xinput29 wdata[32] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__dlymetal6s2s_1
X_1150_ net45 net516 _0379_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_9_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1081_ net9 net515 _0880_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__mux2_1
X_1983_ clknet_leaf_10_clk _0195_ VGND VGND VPWR VPWR mem\[2\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_0934_ net321 net12 _0799_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__mux2_1
X_1417_ _0530_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_58_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1348_ _0492_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__clkbuf_1
X_1279_ _0456_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_5_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1202_ net1 net2 VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__and2b_1
X_1133_ net36 net488 _0368_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1064_ net70 net473 _0869_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1966_ clknet_leaf_30_clk _0178_ VGND VGND VPWR VPWR mem\[2\]\[34\] sky130_fd_sc_hd__dfxtp_1
X_1897_ clknet_leaf_0_clk _0109_ VGND VGND VPWR VPWR mem\[0\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_0917_ net292 net75 _0788_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold7 net139 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_60_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1820_ clknet_leaf_2_clk _0032_ VGND VGND VPWR VPWR mem\[3\]\[32\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_17_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1751_ mem\[3\]\[60\] _0585_ _0706_ mem\[2\]\[60\] _0746_ VGND VGND VPWR VPWR _0759_
+ sky130_fd_sc_hd__a221o_1
Xhold407 mem\[0\]\[57\] VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__dlygate4sd3_1
X_1682_ mem\[3\]\[40\] _0680_ _0706_ mem\[2\]\[40\] _0709_ VGND VGND VPWR VPWR _0710_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_40_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold418 net79 VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1116_ _0369_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__clkbuf_1
X_1047_ net377 net72 _0787_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2096_ clknet_leaf_27_clk net212 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1949_ clknet_leaf_25_clk _0161_ VGND VGND VPWR VPWR mem\[2\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_8_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1803_ clknet_leaf_26_clk _0015_ VGND VGND VPWR VPWR mem\[3\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1734_ mem\[3\]\[55\] _0585_ _0706_ mem\[2\]\[55\] _0746_ VGND VGND VPWR VPWR _0747_
+ sky130_fd_sc_hd__a221o_1
Xhold215 mem\[2\]\[44\] VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__dlygate4sd3_1
Xhold226 mem\[2\]\[69\] VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__dlygate4sd3_1
X_1665_ mem\[0\]\[35\] _0683_ _0659_ mem\[1\]\[35\] _0697_ VGND VGND VPWR VPWR _0698_
+ sky130_fd_sc_hd__a221o_1
Xhold248 mem\[1\]\[69\] VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__dlygate4sd3_1
Xhold259 mem\[1\]\[35\] VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__dlygate4sd3_1
X_1596_ net567 _0646_ _0581_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__mux2_1
Xhold204 mem\[3\]\[21\] VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__dlygate4sd3_1
Xhold237 mem\[0\]\[28\] VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2079_ clknet_leaf_22_clk net188 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1450_ net40 net545 _0545_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1381_ _0511_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__clkbuf_1
X_2002_ clknet_leaf_18_clk _0214_ VGND VGND VPWR VPWR mem\[2\]\[70\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_26_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1717_ mem\[3\]\[50\] _0680_ _0706_ mem\[2\]\[50\] _0709_ VGND VGND VPWR VPWR _0735_
+ sky130_fd_sc_hd__a221o_1
X_1648_ net266 _0664_ _0682_ _0685_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__o22a_1
XFILLER_0_6_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1579_ _0582_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0950_ _0815_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
Xoutput117 net117 VGND VGND VPWR VPWR rdata[46] sky130_fd_sc_hd__clkbuf_4
X_1502_ net67 net305 _0567_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__mux2_1
Xoutput139 net139 VGND VGND VPWR VPWR rdata[66] sky130_fd_sc_hd__buf_2
Xoutput128 net128 VGND VGND VPWR VPWR rdata[56] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput106 net106 VGND VGND VPWR VPWR rdata[36] sky130_fd_sc_hd__clkbuf_4
X_1433_ net31 net449 _0534_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__mux2_1
X_1295_ net40 net527 _0462_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__mux2_1
X_1364_ net15 net432 _0501_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput19 wdata[23] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_1
XFILLER_0_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1080_ _0884_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__clkbuf_1
X_1982_ clknet_leaf_9_clk _0194_ VGND VGND VPWR VPWR mem\[2\]\[50\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_23_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0933_ _0806_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_21_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1347_ net67 net314 _0484_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__mux2_1
X_1416_ net22 net401 _0523_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1278_ net31 net450 _0451_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1201_ _0413_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__clkbuf_1
X_1132_ _0377_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__clkbuf_1
X_1063_ _0875_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__clkbuf_1
X_1965_ clknet_leaf_0_clk _0177_ VGND VGND VPWR VPWR mem\[2\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0916_ _0797_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
X_1896_ clknet_leaf_0_clk _0108_ VGND VGND VPWR VPWR mem\[0\]\[36\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_3_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold8 _0354_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_60_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1750_ mem\[0\]\[60\] _0590_ _0721_ mem\[1\]\[60\] VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_17_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold408 mem\[1\]\[46\] VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__dlygate4sd3_1
X_1681_ _0593_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__buf_4
Xhold419 net85 VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1046_ _0865_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__clkbuf_1
X_1115_ net27 net529 _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__mux2_1
X_2095_ clknet_leaf_23_clk net160 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1948_ clknet_leaf_23_clk _0160_ VGND VGND VPWR VPWR mem\[2\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_1879_ clknet_leaf_23_clk _0091_ VGND VGND VPWR VPWR mem\[0\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_2_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1733_ _0593_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_25_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1802_ clknet_leaf_23_clk _0014_ VGND VGND VPWR VPWR mem\[3\]\[14\] sky130_fd_sc_hd__dfxtp_1
Xhold249 mem\[0\]\[65\] VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__dlygate4sd3_1
X_1664_ _0607_ _0608_ mem\[3\]\[35\] VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__and3_1
Xhold205 mem\[0\]\[33\] VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__dlygate4sd3_1
Xhold216 mem\[2\]\[33\] VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__dlygate4sd3_1
Xhold238 mem\[1\]\[17\] VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__dlygate4sd3_1
X_1595_ mem\[0\]\[17\] mem\[1\]\[17\] mem\[2\]\[17\] mem\[3\]\[17\] _0611_ _0612_
+ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__mux4_1
XFILLER_0_0_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold227 mem\[0\]\[9\] VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__dlygate4sd3_1
X_2147_ clknet_leaf_18_clk net259 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__dfxtp_1
X_1029_ net306 net62 _0854_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2078_ clknet_leaf_20_clk net172 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1380_ net75 net357 _0501_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__mux2_1
X_2001_ clknet_leaf_15_clk _0213_ VGND VGND VPWR VPWR mem\[2\]\[69\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1716_ mem\[0\]\[50\] _0590_ _0721_ mem\[1\]\[50\] VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__a22o_1
XFILLER_0_45_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1647_ mem\[0\]\[30\] _0683_ _0659_ mem\[1\]\[30\] _0684_ VGND VGND VPWR VPWR _0685_
+ sky130_fd_sc_hd__a221o_1
X_1578_ _0633_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_55_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput107 net107 VGND VGND VPWR VPWR rdata[37] sky130_fd_sc_hd__clkbuf_4
Xoutput118 net118 VGND VGND VPWR VPWR rdata[47] sky130_fd_sc_hd__clkbuf_4
Xoutput129 net129 VGND VGND VPWR VPWR rdata[57] sky130_fd_sc_hd__buf_2
X_1501_ _0574_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1432_ _0538_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__clkbuf_1
X_1363_ _0502_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1294_ _0464_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1981_ clknet_leaf_6_clk _0193_ VGND VGND VPWR VPWR mem\[2\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_0932_ net332 net11 _0799_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__mux2_1
X_1346_ _0491_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__clkbuf_1
X_1415_ _0529_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__clkbuf_1
X_1277_ _0455_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_22_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_22_clk sky130_fd_sc_hd__clkbuf_8
X_1200_ net72 net497 _0868_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1131_ net35 net331 _0368_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__mux2_1
X_1062_ net59 net506 _0869_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_13_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_43_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1895_ clknet_leaf_2_clk _0107_ VGND VGND VPWR VPWR mem\[0\]\[35\] sky130_fd_sc_hd__dfxtp_1
X_1964_ clknet_leaf_2_clk _0176_ VGND VGND VPWR VPWR mem\[2\]\[32\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0915_ net294 net74 _0788_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1329_ _0482_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_49_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_58_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold9 net92 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_60_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1680_ mem\[0\]\[40\] _0651_ _0637_ mem\[1\]\[40\] VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__a22o_1
Xhold409 mem\[1\]\[32\] VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_2_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_2_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_29_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1114_ _0868_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__buf_4
X_1045_ net275 net71 _0787_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2094_ clknet_leaf_24_clk net251 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1878_ clknet_leaf_24_clk _0090_ VGND VGND VPWR VPWR mem\[0\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1947_ clknet_leaf_25_clk _0159_ VGND VGND VPWR VPWR mem\[2\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1732_ mem\[0\]\[55\] _0590_ _0721_ mem\[1\]\[55\] VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__a22o_1
Xhold206 mem\[0\]\[66\] VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__dlygate4sd3_1
X_1663_ net189 _0597_ _0604_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__a21o_1
XFILLER_0_25_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1801_ clknet_leaf_22_clk _0013_ VGND VGND VPWR VPWR mem\[3\]\[13\] sky130_fd_sc_hd__dfxtp_1
Xhold217 mem\[1\]\[14\] VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__dlygate4sd3_1
Xhold228 net125 VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__dlygate4sd3_1
Xhold239 mem\[1\]\[11\] VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__dlygate4sd3_1
X_1594_ net169 _0634_ _0644_ _0645_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__o22a_1
XFILLER_0_0_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2146_ clknet_leaf_17_clk net210 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dfxtp_1
X_2077_ clknet_leaf_20_clk net186 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1028_ _0856_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_36_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2000_ clknet_leaf_14_clk _0212_ VGND VGND VPWR VPWR mem\[2\]\[68\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_26_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1715_ net191 _0727_ _0732_ _0733_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__o22a_1
X_1646_ _0607_ _0608_ mem\[3\]\[30\] VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__and3_1
X_1577_ net565 _0632_ _0582_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__mux2_1
X_2129_ clknet_leaf_12_clk _0341_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_47_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput119 net119 VGND VGND VPWR VPWR rdata[48] sky130_fd_sc_hd__clkbuf_4
X_1500_ net66 net406 _0567_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__mux2_1
Xoutput108 net108 VGND VGND VPWR VPWR rdata[38] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_35_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1293_ net39 net343 _0462_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__mux2_1
X_1362_ net4 net489 _0501_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__mux2_1
X_1431_ net30 net337 _0534_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__mux2_1
Xoutput90 net90 VGND VGND VPWR VPWR rdata[21] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1629_ net213 _0664_ _0668_ _0671_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_52_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1980_ clknet_leaf_6_clk _0192_ VGND VGND VPWR VPWR mem\[2\]\[48\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0931_ _0805_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
X_1345_ net66 net400 _0484_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__mux2_1
X_1276_ net30 net364 _0451_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1414_ net21 net430 _0523_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1130_ _0376_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1061_ _0874_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1963_ clknet_leaf_1_clk _0175_ VGND VGND VPWR VPWR mem\[2\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_0914_ _0796_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
X_1894_ clknet_leaf_0_clk _0106_ VGND VGND VPWR VPWR mem\[0\]\[34\] sky130_fd_sc_hd__dfxtp_1
X_1328_ net57 net326 _0473_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__mux2_1
X_1259_ net21 net491 _0440_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1044_ _0864_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__clkbuf_1
X_2093_ clknet_leaf_25_clk _0305_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfxtp_1
X_1113_ _0367_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1946_ clknet_leaf_27_clk _0158_ VGND VGND VPWR VPWR mem\[2\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_1877_ clknet_leaf_25_clk _0089_ VGND VGND VPWR VPWR mem\[0\]\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1800_ clknet_leaf_18_clk _0012_ VGND VGND VPWR VPWR mem\[3\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_13_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold207 mem\[0\]\[52\] VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__dlygate4sd3_1
Xhold218 mem\[1\]\[47\] VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__dlygate4sd3_1
X_1731_ net457 _0727_ _0742_ _0744_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__o22a_1
Xhold229 mem\[3\]\[71\] VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__dlygate4sd3_1
X_1662_ _0582_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__clkbuf_4
X_1593_ mem\[0\]\[16\] _0606_ _0639_ mem\[2\]\[16\] _0624_ VGND VGND VPWR VPWR _0645_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_0_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1027_ net286 net61 _0854_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2145_ clknet_leaf_16_clk net154 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__dfxtp_1
X_2076_ clknet_leaf_20_clk net263 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfxtp_1
X_1929_ clknet_leaf_16_clk _0141_ VGND VGND VPWR VPWR mem\[0\]\[69\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold90 _0303_ VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_33_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1714_ mem\[2\]\[49\] _0669_ _0716_ mem\[1\]\[49\] _0709_ VGND VGND VPWR VPWR _0733_
+ sky130_fd_sc_hd__a221o_1
X_1645_ _0589_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__buf_4
X_1576_ mem\[0\]\[12\] mem\[1\]\[12\] mem\[2\]\[12\] mem\[3\]\[12\] _0611_ _0612_
+ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__mux4_1
X_2059_ clknet_leaf_11_clk _0271_ VGND VGND VPWR VPWR mem\[1\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_2128_ clknet_leaf_8_clk net196 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput109 net109 VGND VGND VPWR VPWR rdata[39] sky130_fd_sc_hd__clkbuf_4
X_1430_ _0537_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__clkbuf_1
X_1292_ _0463_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__clkbuf_1
Xoutput91 net91 VGND VGND VPWR VPWR rdata[22] sky130_fd_sc_hd__clkbuf_4
Xoutput80 net80 VGND VGND VPWR VPWR rdata[12] sky130_fd_sc_hd__buf_2
X_1361_ _0500_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__buf_4
XFILLER_0_41_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1559_ net177 _0583_ _0618_ _0620_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__o22a_1
XFILLER_0_1_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1628_ mem\[2\]\[25\] _0669_ _0659_ mem\[1\]\[25\] _0670_ VGND VGND VPWR VPWR _0671_
+ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_52_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold390 mem\[1\]\[24\] VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__dlygate4sd3_1
X_0930_ net289 net10 _0799_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1413_ _0528_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__clkbuf_1
X_1344_ _0490_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__clkbuf_1
X_1275_ _0454_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1060_ net48 net298 _0869_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_25_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1962_ clknet_leaf_1_clk _0174_ VGND VGND VPWR VPWR mem\[2\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1893_ clknet_leaf_0_clk _0105_ VGND VGND VPWR VPWR mem\[0\]\[33\] sky130_fd_sc_hd__dfxtp_1
X_0913_ net313 net73 _0788_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1327_ _0481_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__clkbuf_1
X_1189_ _0407_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__clkbuf_1
X_1258_ _0445_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1043_ net297 net69 _0854_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__mux2_1
X_1112_ net25 net340 _0891_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__mux2_1
X_2092_ clknet_leaf_23_clk net170 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1945_ clknet_leaf_23_clk _0157_ VGND VGND VPWR VPWR mem\[2\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_16_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1876_ clknet_leaf_23_clk _0088_ VGND VGND VPWR VPWR mem\[0\]\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold208 mem\[1\]\[53\] VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__dlygate4sd3_1
X_1730_ net415 _0683_ _0706_ mem\[2\]\[54\] _0743_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__a221o_1
Xhold219 mem\[3\]\[23\] VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__dlygate4sd3_1
X_1592_ mem\[3\]\[16\] _0586_ _0637_ mem\[1\]\[16\] VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__a22o_1
XFILLER_0_13_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1661_ net173 _0664_ _0693_ _0694_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__o22a_1
XFILLER_0_21_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2144_ clknet_leaf_14_clk net152 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__dfxtp_1
X_1026_ _0855_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_36_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2075_ clknet_leaf_18_clk _0287_ VGND VGND VPWR VPWR mem\[1\]\[71\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_28_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1928_ clknet_leaf_14_clk _0140_ VGND VGND VPWR VPWR mem\[0\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_1859_ clknet_leaf_18_clk _0071_ VGND VGND VPWR VPWR mem\[3\]\[71\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_12_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold80 _0333_ VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold91 net81 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__dlygate4sd3_1
X_1713_ mem\[3\]\[49\] _0672_ _0596_ mem\[0\]\[49\] VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1644_ mem\[2\]\[30\] _0597_ _0604_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__a21o_1
X_1575_ _0631_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2127_ clknet_leaf_10_clk net257 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1009_ _0846_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__clkbuf_1
X_2058_ clknet_leaf_10_clk _0270_ VGND VGND VPWR VPWR mem\[1\]\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1360_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1291_ net38 net541 _0462_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__mux2_1
Xoutput81 net81 VGND VGND VPWR VPWR rdata[13] sky130_fd_sc_hd__clkbuf_4
Xoutput92 net92 VGND VGND VPWR VPWR rdata[23] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1489_ _0568_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__clkbuf_1
X_1627_ _0593_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__clkbuf_4
X_1558_ mem\[2\]\[6\] _0619_ _0600_ mem\[1\]\[6\] _0594_ VGND VGND VPWR VPWR _0620_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_49_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold380 mem\[2\]\[3\] VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_17_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold391 mem\[0\]\[45\] VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_25_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_25_clk sky130_fd_sc_hd__clkbuf_8
X_1343_ net65 net413 _0484_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__mux2_1
X_1412_ net20 net538 _0523_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__mux2_1
X_1274_ net29 net316 _0451_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_16_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_61_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0989_ net425 net41 _0832_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_57_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_0_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1892_ clknet_leaf_1_clk _0104_ VGND VGND VPWR VPWR mem\[0\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_1961_ clknet_leaf_29_clk _0173_ VGND VGND VPWR VPWR mem\[2\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_0912_ _0795_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_5_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_45_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1326_ net56 net510 _0473_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1188_ net65 net397 _0401_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__mux2_1
X_1257_ net20 net417 _0440_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_19_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1042_ _0863_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1111_ _0366_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_16_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2091_ clknet_leaf_24_clk net238 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1875_ clknet_leaf_24_clk _0087_ VGND VGND VPWR VPWR mem\[0\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_1944_ clknet_leaf_24_clk _0156_ VGND VGND VPWR VPWR mem\[2\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_1309_ net47 net336 _0462_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_39_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold209 mem\[1\]\[9\] VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__dlygate4sd3_1
X_1591_ net83 _0634_ _0641_ _0643_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__o22a_1
X_1660_ mem\[3\]\[34\] _0680_ _0639_ mem\[2\]\[34\] _0670_ VGND VGND VPWR VPWR _0694_
+ sky130_fd_sc_hd__a221o_1
X_2143_ clknet_leaf_12_clk _0355_ VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__dfxtp_1
X_1025_ net404 net60 _0854_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2074_ clknet_leaf_17_clk _0286_ VGND VGND VPWR VPWR mem\[1\]\[70\] sky130_fd_sc_hd__dfxtp_1
X_1927_ clknet_leaf_13_clk _0139_ VGND VGND VPWR VPWR mem\[0\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_1858_ clknet_leaf_18_clk _0070_ VGND VGND VPWR VPWR mem\[3\]\[70\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1789_ clknet_leaf_19_clk _0001_ VGND VGND VPWR VPWR mem\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_10_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold81 net133 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dlygate4sd3_1
Xhold92 _0301_ VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__dlygate4sd3_1
Xhold70 _0316_ VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_45_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_1 net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1712_ net215 _0727_ _0730_ _0731_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__o22a_1
XFILLER_0_5_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1643_ net193 _0664_ _0679_ _0681_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__o22a_1
X_1574_ net566 _0630_ _0582_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__mux2_1
X_2057_ clknet_leaf_12_clk _0269_ VGND VGND VPWR VPWR mem\[1\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_2126_ clknet_leaf_11_clk net202 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dfxtp_1
X_1008_ net315 net51 _0843_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput82 net82 VGND VGND VPWR VPWR rdata[14] sky130_fd_sc_hd__clkbuf_4
Xoutput93 net93 VGND VGND VPWR VPWR rdata[24] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_46_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1290_ _0417_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__buf_4
XFILLER_0_58_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1626_ _0415_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__buf_4
XFILLER_0_26_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1488_ net60 net550 _0567_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__mux2_1
X_1557_ _0415_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__buf_4
X_2109_ clknet_leaf_0_clk _0321_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold381 mem\[0\]\[30\] VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__dlygate4sd3_1
Xhold392 mem\[1\]\[3\] VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__dlygate4sd3_1
Xhold370 mem\[1\]\[2\] VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1342_ _0489_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__clkbuf_1
X_1411_ _0527_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__clkbuf_1
X_1273_ _0453_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0988_ _0835_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
X_1609_ mem\[3\]\[21\] _0586_ _0591_ mem\[2\]\[21\] VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_57_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0911_ net347 net70 _0788_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1960_ clknet_leaf_29_clk _0172_ VGND VGND VPWR VPWR mem\[2\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_1891_ clknet_leaf_1_clk _0103_ VGND VGND VPWR VPWR mem\[0\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1325_ _0480_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__clkbuf_1
X_1256_ _0444_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_62_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1187_ _0406_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_19_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2090_ clknet_leaf_23_clk net200 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfxtp_1
X_1110_ net24 net385 _0891_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__mux2_1
X_1041_ net319 net68 _0854_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1874_ clknet_leaf_24_clk _0086_ VGND VGND VPWR VPWR mem\[0\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_1943_ clknet_leaf_24_clk _0155_ VGND VGND VPWR VPWR mem\[2\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1308_ _0471_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_39_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1239_ _0435_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1590_ mem\[0\]\[15\] _0606_ _0639_ mem\[2\]\[15\] _0642_ VGND VGND VPWR VPWR _0643_
+ sky130_fd_sc_hd__a221o_1
X_2142_ clknet_leaf_15_clk net156 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dfxtp_1
X_1024_ _0787_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__buf_4
X_2073_ clknet_leaf_16_clk _0285_ VGND VGND VPWR VPWR mem\[1\]\[69\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_46_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_55_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1926_ clknet_leaf_15_clk _0138_ VGND VGND VPWR VPWR mem\[0\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_1857_ clknet_leaf_15_clk _0069_ VGND VGND VPWR VPWR mem\[3\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_1788_ clknet_leaf_20_clk _0000_ VGND VGND VPWR VPWR mem\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold82 _0348_ VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dlygate4sd3_1
Xhold71 net114 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dlygate4sd3_1
Xhold93 net115 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__dlygate4sd3_1
Xhold60 _0330_ VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dlygate4sd3_1
X_1711_ mem\[3\]\[48\] _0680_ _0706_ mem\[2\]\[48\] _0709_ VGND VGND VPWR VPWR _0731_
+ sky130_fd_sc_hd__a221o_1
XANTENNA_2 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1642_ mem\[3\]\[29\] _0680_ _0639_ mem\[2\]\[29\] _0670_ VGND VGND VPWR VPWR _0681_
+ sky130_fd_sc_hd__a221o_1
X_1573_ mem\[0\]\[11\] mem\[1\]\[11\] mem\[2\]\[11\] mem\[3\]\[11\] _0611_ _0612_
+ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__mux4_1
X_2056_ clknet_leaf_9_clk _0268_ VGND VGND VPWR VPWR mem\[1\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_2125_ clknet_leaf_7_clk net192 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_49_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1007_ _0845_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
X_1909_ clknet_leaf_6_clk _0121_ VGND VGND VPWR VPWR mem\[0\]\[49\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_32_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput83 net83 VGND VGND VPWR VPWR rdata[15] sky130_fd_sc_hd__clkbuf_4
Xoutput94 net94 VGND VGND VPWR VPWR rdata[25] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_46_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1556_ mem\[3\]\[6\] _0586_ _0617_ mem\[0\]\[6\] VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1625_ mem\[3\]\[25\] _0586_ _0617_ mem\[0\]\[25\] VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__a22o_1
X_1487_ _0500_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__buf_4
X_2039_ clknet_leaf_3_clk _0251_ VGND VGND VPWR VPWR mem\[1\]\[35\] sky130_fd_sc_hd__dfxtp_1
X_2108_ clknet_leaf_2_clk net273 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dfxtp_1
Xhold393 mem\[2\]\[40\] VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__dlygate4sd3_1
Xhold360 mem\[0\]\[40\] VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__dlygate4sd3_1
Xhold371 mem\[0\]\[20\] VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__dlygate4sd3_1
Xhold382 mem\[0\]\[31\] VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1410_ net19 net534 _0523_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1341_ net64 net459 _0484_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1272_ net28 net549 _0451_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0987_ net350 net40 _0832_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__mux2_1
X_1608_ net211 _0634_ _0654_ _0655_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__o22a_1
X_1539_ _0593_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_57_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold190 mem\[3\]\[39\] VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1890_ clknet_leaf_1_clk _0102_ VGND VGND VPWR VPWR mem\[0\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0910_ _0794_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1324_ net55 net427 _0473_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__mux2_1
X_1186_ net64 net499 _0401_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1255_ net19 net517 _0440_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_62_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1040_ _0862_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1942_ clknet_leaf_22_clk _0154_ VGND VGND VPWR VPWR mem\[2\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1873_ clknet_leaf_24_clk _0085_ VGND VGND VPWR VPWR mem\[0\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_1307_ net46 net341 _0462_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__mux2_1
X_1169_ net55 net383 _0390_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__mux2_1
X_1238_ net10 net403 _0429_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1023_ _0853_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__clkbuf_1
X_2072_ clknet_leaf_14_clk _0284_ VGND VGND VPWR VPWR mem\[1\]\[68\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2141_ clknet_leaf_17_clk net224 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1925_ clknet_leaf_17_clk _0137_ VGND VGND VPWR VPWR mem\[0\]\[65\] sky130_fd_sc_hd__dfxtp_1
X_1856_ clknet_leaf_14_clk _0068_ VGND VGND VPWR VPWR mem\[3\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_1787_ net258 _0582_ _0782_ _0783_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__o22a_1
XFILLER_0_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold50 _0343_ VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__dlygate4sd3_1
Xhold72 _0331_ VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dlygate4sd3_1
Xhold83 net134 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dlygate4sd3_1
Xhold94 _0332_ VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 net144 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dlygate4sd3_1
X_1710_ mem\[0\]\[48\] _0651_ _0721_ mem\[1\]\[48\] VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__a22o_1
X_1641_ _0585_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__buf_4
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1572_ net167 _0583_ _0628_ _0629_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__o22a_1
XFILLER_0_21_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2124_ clknet_leaf_5_clk net216 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_49_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2055_ clknet_leaf_10_clk _0267_ VGND VGND VPWR VPWR mem\[1\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_1006_ net324 net50 _0843_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_16_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1908_ clknet_leaf_6_clk _0120_ VGND VGND VPWR VPWR mem\[0\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_1839_ clknet_leaf_10_clk _0051_ VGND VGND VPWR VPWR mem\[3\]\[51\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_32_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput84 net84 VGND VGND VPWR VPWR rdata[16] sky130_fd_sc_hd__clkbuf_4
Xoutput95 net95 VGND VGND VPWR VPWR rdata[26] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_46_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_28_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_28_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_26_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1555_ _0589_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__buf_4
X_1624_ net221 _0664_ _0665_ _0667_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__o22a_1
X_1486_ _0566_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_19_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_8
X_2107_ clknet_leaf_1_clk net261 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2038_ clknet_leaf_30_clk _0250_ VGND VGND VPWR VPWR mem\[1\]\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold361 mem\[0\]\[49\] VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__dlygate4sd3_1
Xhold394 mem\[1\]\[43\] VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__dlygate4sd3_1
Xhold350 mem\[0\]\[1\] VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__dlygate4sd3_1
Xhold383 mem\[1\]\[30\] VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__dlygate4sd3_1
Xhold372 mem\[2\]\[6\] VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1340_ _0488_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1271_ _0452_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_8_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_8
X_0986_ _0834_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1469_ net50 net495 _0556_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__mux2_1
X_1607_ mem\[2\]\[20\] _0619_ _0600_ mem\[1\]\[20\] _0624_ VGND VGND VPWR VPWR _0655_
+ sky130_fd_sc_hd__a221o_1
X_1538_ net171 _0583_ _0602_ _0603_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_57_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_19_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold180 mem\[3\]\[10\] VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold191 mem\[3\]\[36\] VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1323_ _0479_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__clkbuf_1
X_1185_ _0405_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__clkbuf_1
X_1254_ _0443_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_62_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0969_ _0825_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_4_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1941_ clknet_leaf_21_clk _0153_ VGND VGND VPWR VPWR mem\[2\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_1872_ clknet_leaf_19_clk _0084_ VGND VGND VPWR VPWR mem\[0\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1306_ _0470_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__clkbuf_1
X_1168_ _0396_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__clkbuf_1
X_1237_ _0434_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__clkbuf_1
X_1099_ _0360_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_38_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2140_ clknet_leaf_16_clk net206 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dfxtp_1
X_1022_ net303 net58 _0843_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__mux2_1
X_2071_ clknet_leaf_12_clk _0283_ VGND VGND VPWR VPWR mem\[1\]\[67\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1855_ clknet_leaf_13_clk _0067_ VGND VGND VPWR VPWR mem\[3\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_1924_ clknet_leaf_16_clk _0136_ VGND VGND VPWR VPWR mem\[0\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_1786_ mem\[0\]\[71\] _0589_ _0619_ mem\[2\]\[71\] _0593_ VGND VGND VPWR VPWR _0783_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_46_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold40 _0291_ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__dlygate4sd3_1
Xhold84 _0349_ VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 _0358_ VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 net82 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 net93 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dlygate4sd3_1
Xhold95 mem\[2\]\[26\] VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_7_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1640_ mem\[0\]\[29\] _0651_ _0637_ mem\[1\]\[29\] VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__a22o_1
X_1571_ mem\[0\]\[10\] _0606_ _0600_ mem\[1\]\[10\] _0624_ VGND VGND VPWR VPWR _0629_
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_21_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2123_ clknet_leaf_9_clk net247 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dfxtp_1
X_2054_ clknet_leaf_8_clk _0266_ VGND VGND VPWR VPWR mem\[1\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_1005_ _0844_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1838_ clknet_leaf_11_clk _0050_ VGND VGND VPWR VPWR mem\[3\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_1907_ clknet_leaf_9_clk _0119_ VGND VGND VPWR VPWR mem\[0\]\[47\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_32_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1769_ mem\[0\]\[66\] _0590_ _0721_ mem\[1\]\[66\] VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__a22o_1
XFILLER_0_12_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_33_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput96 net96 VGND VGND VPWR VPWR rdata[27] sky130_fd_sc_hd__clkbuf_4
Xoutput85 net85 VGND VGND VPWR VPWR rdata[17] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_46_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1485_ net58 net311 _0556_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__mux2_1
X_1623_ mem\[0\]\[24\] _0606_ _0659_ mem\[1\]\[24\] _0666_ VGND VGND VPWR VPWR _0667_
+ sky130_fd_sc_hd__a221o_1
X_1554_ net161 _0583_ _0615_ _0616_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__o22a_1
.ends
