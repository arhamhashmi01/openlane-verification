* NGSPICE file created from dff_ram_8x72.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

.subckt dff_ram_8x72 VGND VPWR address[0] address[1] address[2] clk rdata[0] rdata[10]
+ rdata[11] rdata[12] rdata[13] rdata[14] rdata[15] rdata[16] rdata[17] rdata[18]
+ rdata[19] rdata[1] rdata[20] rdata[21] rdata[22] rdata[23] rdata[24] rdata[25] rdata[26]
+ rdata[27] rdata[28] rdata[29] rdata[2] rdata[30] rdata[31] rdata[32] rdata[33] rdata[34]
+ rdata[35] rdata[36] rdata[37] rdata[38] rdata[39] rdata[3] rdata[40] rdata[41] rdata[42]
+ rdata[43] rdata[44] rdata[45] rdata[46] rdata[47] rdata[48] rdata[49] rdata[4] rdata[50]
+ rdata[51] rdata[52] rdata[53] rdata[54] rdata[55] rdata[56] rdata[57] rdata[58]
+ rdata[59] rdata[5] rdata[60] rdata[61] rdata[62] rdata[63] rdata[64] rdata[65] rdata[66]
+ rdata[67] rdata[68] rdata[69] rdata[6] rdata[70] rdata[71] rdata[7] rdata[8] rdata[9]
+ wdata[0] wdata[10] wdata[11] wdata[12] wdata[13] wdata[14] wdata[15] wdata[16] wdata[17]
+ wdata[18] wdata[19] wdata[1] wdata[20] wdata[21] wdata[22] wdata[23] wdata[24] wdata[25]
+ wdata[26] wdata[27] wdata[28] wdata[29] wdata[2] wdata[30] wdata[31] wdata[32] wdata[33]
+ wdata[34] wdata[35] wdata[36] wdata[37] wdata[38] wdata[39] wdata[3] wdata[40] wdata[41]
+ wdata[42] wdata[43] wdata[44] wdata[45] wdata[46] wdata[47] wdata[48] wdata[49]
+ wdata[4] wdata[50] wdata[51] wdata[52] wdata[53] wdata[54] wdata[55] wdata[56] wdata[57]
+ wdata[58] wdata[59] wdata[5] wdata[60] wdata[61] wdata[62] wdata[63] wdata[64] wdata[65]
+ wdata[66] wdata[67] wdata[68] wdata[69] wdata[6] wdata[70] wdata[71] wdata[7] wdata[8]
+ wdata[9] wr_n
X_3155_ net769 net21 _1519_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__mux2_1
X_3086_ net65 net954 _1482_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__mux2_1
X_2106_ _0858_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__clkbuf_1
X_2037_ net488 net41 _0817_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3988_ clknet_leaf_33_clk _0214_ VGND VGND VPWR VPWR instance_1.rdata\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2939_ net68 net817 _1401_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold340 instance_1.mem\[1\]\[43\] VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__dlygate4sd3_1
Xhold351 instance_0.rdata\[50\] VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__dlygate4sd3_1
Xhold362 instance_1.mem\[3\]\[16\] VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold395 instance_1.mem\[0\]\[69\] VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__dlygate4sd3_1
Xhold384 instance_1.rdata\[10\] VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__dlygate4sd3_1
Xhold373 instance_1.mem\[3\]\[6\] VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3911_ clknet_leaf_37_clk net236 VGND VGND VPWR VPWR instance_0.rdata\[23\] sky130_fd_sc_hd__dfxtp_1
X_3842_ clknet_leaf_33_clk _0068_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[26\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_62_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3773_ _1850_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_81_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2724_ instance_1.mem\[1\]\[49\] _1102_ _0957_ instance_1.mem\[3\]\[49\] _1263_ VGND
+ VGND VPWR VPWR _1286_ sky130_fd_sc_hd__a221o_1
X_2655_ instance_1.mem\[3\]\[29\] _1184_ _1197_ instance_1.mem\[2\]\[29\] VGND VGND
+ VPWR VPWR _1237_ sky130_fd_sc_hd__a22o_1
X_4325_ clknet_leaf_53_clk _0551_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_2586_ instance_1.mem\[0\]\[10\] instance_1.mem\[1\]\[10\] instance_1.mem\[2\]\[10\]
+ instance_1.mem\[3\]\[10\] _1082_ _1130_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__mux4_1
XFILLER_0_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4256_ clknet_leaf_51_clk _0482_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_4187_ clknet_leaf_49_clk _0413_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_3207_ _1496_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__buf_4
X_3138_ net677 net12 _1508_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3069_ net56 net632 _1471_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold170 _0242_ VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__dlygate4sd3_1
Xhold192 _0188_ VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__dlygate4sd3_1
Xhold181 instance_1.rdata\[24\] VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2440_ _1079_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__clkbuf_1
X_2371_ net363 _1024_ _1027_ _1029_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__o22a_1
XFILLER_0_75_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4110_ clknet_leaf_55_clk _0336_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_4041_ clknet_leaf_50_clk _0267_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_67_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3825_ clknet_leaf_50_clk _0051_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_3756_ net724 net17 _1838_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2707_ instance_1.mem\[0\]\[44\] _1190_ _1177_ instance_1.mem\[3\]\[44\] VGND VGND
+ VPWR VPWR _1274_ sky130_fd_sc_hd__a22o_1
XFILLER_0_40_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3687_ _1739_ VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__buf_4
XFILLER_0_42_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2638_ instance_1.mem\[1\]\[24\] _1224_ _1177_ instance_1.mem\[3\]\[24\] VGND VGND
+ VPWR VPWR _1225_ sky130_fd_sc_hd__a22o_1
X_2569_ net281 _1163_ _1172_ _1174_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__o22a_1
X_4308_ clknet_leaf_57_clk _0534_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_4239_ clknet_leaf_56_clk _0465_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[63\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_38_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_88_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1940_ instance_0.rdata\[41\] instance_1.rdata\[41\] _0766_ VGND VGND VPWR VPWR _0768_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1871_ _0731_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__buf_1
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3610_ net19 net555 _1762_ VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3541_ net656 net63 _1725_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__mux2_1
X_3472_ net592 net27 _1692_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2423_ net155 _1056_ _1066_ _1067_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__o22a_1
X_2354_ instance_0.mem\[3\]\[20\] _1016_ _1008_ instance_0.mem\[2\]\[20\] VGND VGND
+ VPWR VPWR _1017_ sky130_fd_sc_hd__a22o_1
X_2285_ instance_0.mem\[1\]\[2\] _0965_ _0950_ instance_0.mem\[2\]\[2\] _0960_ VGND
+ VGND VPWR VPWR _0966_ sky130_fd_sc_hd__a221o_1
X_4024_ clknet_leaf_3_clk net276 VGND VGND VPWR VPWR instance_1.rdata\[64\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3808_ clknet_leaf_3_clk _0034_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_3739_ net468 net8 _1827_ VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_7_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2070_ net616 net58 _0828_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2972_ _1428_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_32_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1923_ instance_0.rdata\[33\] instance_1.rdata\[33\] _0755_ VGND VGND VPWR VPWR _0759_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1854_ instance_0.rdata\[0\] instance_1.rdata\[0\] _0722_ VGND VGND VPWR VPWR _0723_
+ sky130_fd_sc_hd__mux2_1
Xhold703 instance_0.mem\[1\]\[65\] VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__dlygate4sd3_1
Xhold714 instance_0.mem\[3\]\[36\] VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__dlygate4sd3_1
Xhold736 instance_0.mem\[1\]\[44\] VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__dlygate4sd3_1
Xhold725 instance_0.mem\[0\]\[16\] VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__dlygate4sd3_1
X_3524_ net684 net54 _1714_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__mux2_1
Xhold758 instance_0.mem\[2\]\[2\] VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__dlygate4sd3_1
Xhold747 instance_0.mem\[2\]\[64\] VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__dlygate4sd3_1
X_3455_ net601 net18 _1681_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__mux2_1
Xhold769 instance_0.mem\[0\]\[29\] VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__dlygate4sd3_1
X_2406_ net219 _1024_ _1054_ _1055_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__o22a_1
X_3386_ net563 net62 _1644_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__mux2_1
X_2337_ net165 _0990_ _1003_ _1004_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_4_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2268_ _0944_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__buf_4
X_4007_ clknet_leaf_19_clk _0233_ VGND VGND VPWR VPWR instance_1.rdata\[47\] sky130_fd_sc_hd__dfxtp_1
X_2199_ net45 net889 _0899_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold30 _0220_ VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__dlygate4sd3_1
Xhold41 instance_0.rdata\[36\] VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold63 instance_0.rdata\[25\] VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 _0170_ VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dlygate4sd3_1
Xhold74 _0161_ VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dlygate4sd3_1
Xhold85 instance_0.rdata\[13\] VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dlygate4sd3_1
Xhold96 _0241_ VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_5 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3240_ _1569_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__clkbuf_1
X_3171_ _1533_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__clkbuf_1
X_2122_ net5 net915 _0866_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2053_ _0829_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_17_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2955_ _1419_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__clkbuf_1
X_2886_ _1382_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__clkbuf_1
X_1906_ instance_0.rdata\[25\] instance_1.rdata\[25\] _0744_ VGND VGND VPWR VPWR _0750_
+ sky130_fd_sc_hd__mux2_1
Xhold500 instance_0.mem\[1\]\[38\] VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__dlygate4sd3_1
Xhold511 instance_1.mem\[2\]\[25\] VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__dlygate4sd3_1
Xhold544 instance_1.mem\[1\]\[45\] VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__dlygate4sd3_1
Xhold533 instance_0.mem\[2\]\[34\] VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__dlygate4sd3_1
Xhold522 instance_0.mem\[2\]\[59\] VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__dlygate4sd3_1
X_3507_ net666 net45 _1703_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__mux2_1
Xhold555 instance_0.mem\[2\]\[50\] VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__dlygate4sd3_1
Xhold577 instance_0.mem\[1\]\[60\] VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__dlygate4sd3_1
Xhold566 instance_0.mem\[3\]\[64\] VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__dlygate4sd3_1
X_4487_ clknet_leaf_50_clk _0713_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[23\] sky130_fd_sc_hd__dfxtp_1
Xhold588 instance_1.mem\[2\]\[21\] VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__dlygate4sd3_1
X_3438_ net538 net9 _1670_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__mux2_1
Xhold599 instance_0.mem\[1\]\[61\] VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__dlygate4sd3_1
X_3369_ net612 net53 _1633_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__mux2_1
XFILLER_0_67_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput86 net86 VGND VGND VPWR VPWR rdata[18] sky130_fd_sc_hd__clkbuf_4
Xoutput97 net97 VGND VGND VPWR VPWR rdata[28] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2740_ _1165_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__buf_4
X_2671_ _0978_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__buf_4
X_4410_ clknet_leaf_41_clk _0636_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4341_ clknet_leaf_38_clk _0567_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4272_ clknet_leaf_35_clk _0498_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_3223_ _1560_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__clkbuf_1
X_3154_ _1524_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__clkbuf_1
X_2105_ net26 net742 _0855_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__mux2_1
X_3085_ _1487_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__clkbuf_1
X_2036_ _0820_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3987_ clknet_leaf_32_clk net370 VGND VGND VPWR VPWR instance_1.rdata\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2938_ _1409_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2869_ _1373_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_20_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold330 instance_1.mem\[2\]\[38\] VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__dlygate4sd3_1
Xhold352 instance_0.mem\[2\]\[63\] VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__dlygate4sd3_1
Xhold341 instance_1.mem\[1\]\[31\] VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold363 instance_1.mem\[2\]\[1\] VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__dlygate4sd3_1
Xhold385 instance_1.mem\[1\]\[24\] VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__dlygate4sd3_1
Xhold396 instance_0.mem\[0\]\[54\] VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__dlygate4sd3_1
Xhold374 instance_1.mem\[2\]\[53\] VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_3_6__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3910_ clknet_leaf_38_clk net170 VGND VGND VPWR VPWR instance_0.rdata\[22\] sky130_fd_sc_hd__dfxtp_1
X_3841_ clknet_leaf_39_clk _0067_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3772_ net534 net25 _0805_ VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__mux2_1
X_2723_ instance_1.mem\[0\]\[49\] _1190_ _1248_ instance_1.mem\[2\]\[49\] VGND VGND
+ VPWR VPWR _1285_ sky130_fd_sc_hd__a22o_1
X_2654_ _1236_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__clkbuf_1
X_2585_ net357 _1163_ _1185_ _1186_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__o22a_1
XFILLER_0_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4324_ clknet_leaf_51_clk _0550_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4255_ clknet_leaf_47_clk _0481_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_3206_ _1551_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__clkbuf_1
X_4186_ clknet_leaf_46_clk _0412_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_3137_ _1515_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__clkbuf_1
X_3068_ _1478_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__clkbuf_1
X_2019_ _0811_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_25_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold171 instance_0.rdata\[0\] VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlygate4sd3_1
Xhold160 _0123_ VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__dlygate4sd3_1
Xhold193 instance_1.rdata\[50\] VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__dlygate4sd3_1
Xhold182 _0210_ VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_502 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2370_ instance_0.mem\[1\]\[24\] _1010_ _0993_ instance_0.mem\[0\]\[24\] _1028_ VGND
+ VGND VPWR VPWR _1029_ sky130_fd_sc_hd__a221o_1
X_4040_ clknet_leaf_48_clk _0266_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_67_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3824_ clknet_leaf_48_clk _0050_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3755_ _1841_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__clkbuf_1
X_2706_ net163 _1261_ _1272_ _1273_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_30_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3686_ _1805_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_18_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2637_ _0938_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__clkbuf_8
X_2568_ instance_1.mem\[0\]\[5\] _1145_ _1127_ instance_1.mem\[2\]\[5\] _1173_ VGND
+ VGND VPWR VPWR _1174_ sky130_fd_sc_hd__a221o_1
X_2499_ net261 _1092_ _1121_ _1123_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__o22a_1
X_4307_ clknet_leaf_11_clk _0533_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_4238_ clknet_leaf_2_clk _0464_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[62\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4169_ clknet_leaf_1_clk _0395_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[65\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_27_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_36_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_45_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1870_ instance_0.rdata\[8\] instance_1.rdata\[8\] _0722_ VGND VGND VPWR VPWR _0731_
+ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_54_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3540_ _1728_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3471_ _1658_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__buf_4
X_2422_ instance_0.mem\[0\]\[38\] _1039_ _1040_ instance_0.mem\[2\]\[38\] _1036_ VGND
+ VGND VPWR VPWR _1067_ sky130_fd_sc_hd__a221o_1
X_2353_ _0956_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_63_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4023_ clknet_leaf_56_clk _0249_ VGND VGND VPWR VPWR instance_1.rdata\[63\] sky130_fd_sc_hd__dfxtp_1
X_2284_ _0803_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__buf_4
XFILLER_0_79_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_72_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3807_ clknet_leaf_55_clk _0033_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_1999_ _0798_ VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__buf_1
X_3738_ _1832_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__clkbuf_1
X_3669_ net50 net756 _1795_ VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_81_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_3_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2971_ net5 net728 _1427_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1922_ _0758_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1853_ _0721_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__buf_4
XFILLER_0_4_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold737 instance_0.mem\[1\]\[42\] VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__dlygate4sd3_1
Xhold715 instance_0.mem\[2\]\[16\] VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__dlygate4sd3_1
Xhold726 instance_0.mem\[2\]\[9\] VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__dlygate4sd3_1
Xhold704 instance_0.mem\[2\]\[24\] VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__dlygate4sd3_1
X_3523_ _1719_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__clkbuf_1
X_3454_ _1683_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__clkbuf_1
Xhold748 instance_0.mem\[0\]\[46\] VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__dlygate4sd3_1
Xhold759 instance_0.mem\[1\]\[47\] VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__dlygate4sd3_1
X_2405_ instance_0.mem\[1\]\[33\] _1010_ _1048_ instance_0.mem\[0\]\[33\] _1036_ VGND
+ VGND VPWR VPWR _1055_ sky130_fd_sc_hd__a221o_1
X_3385_ _1646_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__clkbuf_1
X_2336_ instance_0.mem\[0\]\[15\] _0947_ _0979_ instance_0.mem\[2\]\[15\] _0999_ VGND
+ VGND VPWR VPWR _1004_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_4_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_49_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_49_clk sky130_fd_sc_hd__clkbuf_8
X_2267_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__buf_4
XFILLER_0_79_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4006_ clknet_leaf_20_clk _0232_ VGND VGND VPWR VPWR instance_1.rdata\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2198_ _0906_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold20 _0224_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 instance_0.rdata\[52\] VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 _0150_ VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 _0139_ VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 instance_0.rdata\[37\] VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__dlygate4sd3_1
Xhold97 instance_1.rdata\[44\] VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 _0127_ VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dlygate4sd3_1
Xhold75 instance_0.rdata\[57\] VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_6 net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3170_ net577 net29 _1530_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__mux2_1
X_2121_ _0854_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__buf_4
XFILLER_0_83_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2052_ net718 net49 _0828_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2954_ net26 net906 _1416_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2885_ net40 net885 _1379_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1905_ _0749_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold501 instance_0.mem\[0\]\[26\] VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__dlygate4sd3_1
Xhold545 instance_0.mem\[0\]\[1\] VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__dlygate4sd3_1
Xhold523 instance_1.mem\[3\]\[69\] VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__dlygate4sd3_1
Xhold512 instance_1.mem\[1\]\[5\] VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__dlygate4sd3_1
Xhold534 instance_1.mem\[3\]\[70\] VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__dlygate4sd3_1
X_3506_ _1710_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__clkbuf_1
Xhold556 instance_0.mem\[2\]\[7\] VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__dlygate4sd3_1
Xhold567 instance_0.mem\[1\]\[0\] VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__dlygate4sd3_1
X_4486_ clknet_leaf_37_clk _0712_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[22\] sky130_fd_sc_hd__dfxtp_1
Xhold578 instance_0.mem\[1\]\[57\] VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__dlygate4sd3_1
X_3437_ _1674_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__clkbuf_1
Xhold589 instance_1.mem\[2\]\[68\] VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__dlygate4sd3_1
X_3368_ _1637_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__clkbuf_1
X_2319_ _0956_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__clkbuf_8
X_3299_ _1601_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput87 net87 VGND VGND VPWR VPWR rdata[19] sky130_fd_sc_hd__clkbuf_4
Xoutput98 net98 VGND VGND VPWR VPWR rdata[29] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2670_ net343 _1232_ _1246_ _1247_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__o22a_1
XFILLER_0_41_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4340_ clknet_leaf_35_clk _0566_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_4271_ clknet_leaf_36_clk _0497_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_3222_ net420 net56 _1552_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__mux2_1
X_3153_ net673 net20 _1519_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2104_ _0857_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
X_3084_ net64 net895 _1482_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__mux2_1
X_2035_ net840 net40 _0817_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3986_ clknet_leaf_32_clk net366 VGND VGND VPWR VPWR instance_1.rdata\[26\] sky130_fd_sc_hd__dfxtp_1
X_2937_ net67 net647 _1401_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2868_ net31 net937 _1368_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__mux2_1
X_2799_ net15 net839 _1335_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__mux2_1
Xhold320 instance_1.mem\[1\]\[13\] VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__dlygate4sd3_1
Xhold342 instance_0.mem\[3\]\[38\] VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__dlygate4sd3_1
Xhold353 instance_1.mem\[3\]\[8\] VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__dlygate4sd3_1
Xhold331 instance_1.mem\[3\]\[23\] VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__dlygate4sd3_1
X_4469_ clknet_leaf_53_clk _0695_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xhold375 instance_0.mem\[3\]\[23\] VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__dlygate4sd3_1
Xhold364 instance_0.mem\[3\]\[58\] VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__dlygate4sd3_1
Xhold386 instance_1.mem\[1\]\[29\] VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold397 instance_1.mem\[2\]\[16\] VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3840_ clknet_leaf_35_clk _0066_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3771_ _1849_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_54_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2722_ net273 _1261_ _1283_ _1284_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__o22a_1
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2653_ net473 _1235_ _1188_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__mux2_1
X_2584_ instance_1.mem\[1\]\[9\] _1122_ _1154_ instance_1.mem\[0\]\[9\] _1166_ VGND
+ VGND VPWR VPWR _1186_ sky130_fd_sc_hd__a221o_1
X_4323_ clknet_leaf_55_clk _0549_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4254_ clknet_leaf_55_clk _0480_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3205_ net894 net47 _1541_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__mux2_1
X_4185_ clknet_leaf_50_clk _0411_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_3136_ net510 net11 _1508_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__mux2_1
X_3067_ net55 net879 _1471_ VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__mux2_1
X_2018_ net652 net31 _0806_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_25_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3969_ clknet_leaf_50_clk net358 VGND VGND VPWR VPWR instance_1.rdata\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_72_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold150 _0115_ VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__dlygate4sd3_1
Xhold161 instance_0.rdata\[29\] VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__dlygate4sd3_1
Xhold194 _0236_ VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__dlygate4sd3_1
Xhold183 instance_0.rdata\[16\] VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__dlygate4sd3_1
Xhold172 _0114_ VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_67_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3823_ clknet_leaf_48_clk _0049_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3754_ net662 net16 _1838_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__mux2_1
X_2705_ instance_1.mem\[0\]\[43\] _1252_ _1181_ instance_1.mem\[2\]\[43\] _1263_ VGND
+ VGND VPWR VPWR _1273_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_30_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3685_ net58 net978 _1795_ VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__mux2_1
X_2636_ net315 _1205_ _1222_ _1223_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__o22a_1
X_2567_ _0951_ _0945_ instance_1.mem\[3\]\[5\] VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__and3_1
X_4306_ clknet_leaf_8_clk _0532_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[58\] sky130_fd_sc_hd__dfxtp_1
X_2498_ instance_0.mem\[1\]\[58\] _1122_ _1071_ instance_0.mem\[3\]\[58\] _1074_ VGND
+ VGND VPWR VPWR _1123_ sky130_fd_sc_hd__a221o_1
X_4237_ clknet_leaf_2_clk _0463_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[61\] sky130_fd_sc_hd__dfxtp_1
X_4168_ clknet_leaf_4_clk _0394_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[64\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4099_ clknet_leaf_56_clk _0325_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_3119_ net501 net74 _1497_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_38_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3470_ _1691_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__clkbuf_1
X_2421_ instance_0.mem\[1\]\[38\] _1021_ _1030_ instance_0.mem\[3\]\[38\] VGND VGND
+ VPWR VPWR _1066_ sky130_fd_sc_hd__a22o_1
X_2352_ _1015_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2283_ instance_0.mem\[0\]\[2\] _0963_ _0958_ instance_0.mem\[3\]\[2\] VGND VGND
+ VPWR VPWR _0964_ sky130_fd_sc_hd__a22o_1
XFILLER_0_43_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4022_ clknet_leaf_1_clk _0248_ VGND VGND VPWR VPWR instance_1.rdata\[62\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3806_ clknet_leaf_2_clk _0032_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_1998_ instance_0.rdata\[69\] instance_1.rdata\[69\] _0788_ VGND VGND VPWR VPWR _0798_
+ sky130_fd_sc_hd__mux2_1
X_3737_ net730 net7 _1827_ VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__mux2_1
X_3668_ _1796_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__clkbuf_1
X_2619_ _1211_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__clkbuf_1
X_3599_ net13 net645 _1751_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_7_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2970_ _1415_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__buf_4
XFILLER_0_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1921_ instance_0.rdata\[32\] instance_1.rdata\[32\] _0755_ VGND VGND VPWR VPWR _0758_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1852_ _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__buf_4
XFILLER_0_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold727 instance_0.mem\[0\]\[0\] VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__dlygate4sd3_1
Xhold716 instance_1.mem\[0\]\[54\] VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__dlygate4sd3_1
X_3522_ net477 net53 _1714_ VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__mux2_1
Xhold705 instance_1.mem\[0\]\[29\] VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__dlygate4sd3_1
Xhold749 instance_0.mem\[1\]\[30\] VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__dlygate4sd3_1
X_3453_ net470 net17 _1681_ VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__mux2_1
Xhold738 instance_0.mem\[0\]\[32\] VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__dlygate4sd3_1
X_2404_ instance_0.mem\[3\]\[33\] _1016_ _1008_ instance_0.mem\[2\]\[33\] VGND VGND
+ VPWR VPWR _1054_ sky130_fd_sc_hd__a22o_1
X_3384_ net800 net61 _1644_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__mux2_1
X_2335_ instance_0.mem\[1\]\[15\] _0939_ _0958_ instance_0.mem\[3\]\[15\] VGND VGND
+ VPWR VPWR _1003_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_4_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2266_ _0948_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__clkbuf_2
X_4005_ clknet_leaf_16_clk net256 VGND VGND VPWR VPWR instance_1.rdata\[45\] sky130_fd_sc_hd__dfxtp_1
X_2197_ net44 net896 _0899_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold32 _0166_ VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 _0177_ VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 instance_0.rdata\[22\] VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 instance_0.rdata\[8\] VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 instance_0.rdata\[4\] VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 _0151_ VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 _0230_ VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__dlygate4sd3_1
Xhold76 _0171_ VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 instance_0.rdata\[23\] VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_7 _0978_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2120_ _0865_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
X_2051_ _0805_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__buf_4
XFILLER_0_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2953_ _1418_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1904_ instance_0.rdata\[24\] instance_1.rdata\[24\] _0744_ VGND VGND VPWR VPWR _0749_
+ sky130_fd_sc_hd__mux2_1
X_2884_ _1381_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__clkbuf_1
Xhold502 instance_1.mem\[2\]\[43\] VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold535 instance_0.mem\[0\]\[64\] VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__dlygate4sd3_1
Xhold513 instance_1.mem\[0\]\[71\] VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__dlygate4sd3_1
X_3505_ net583 net44 _1703_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__mux2_1
Xhold524 instance_1.mem\[2\]\[48\] VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__dlygate4sd3_1
Xhold557 instance_0.mem\[1\]\[8\] VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__dlygate4sd3_1
X_4485_ clknet_leaf_40_clk _0711_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold546 instance_1.mem\[1\]\[32\] VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__dlygate4sd3_1
Xhold568 instance_0.mem\[0\]\[55\] VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__dlygate4sd3_1
Xhold579 instance_0.mem\[1\]\[36\] VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__dlygate4sd3_1
X_3436_ net539 net8 _1670_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__mux2_1
X_3367_ net522 net52 _1633_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__mux2_1
X_2318_ _0936_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__buf_4
X_3298_ net475 net16 _1600_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__mux2_1
X_2249_ net72 net977 _0854_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput99 net99 VGND VGND VPWR VPWR rdata[2] sky130_fd_sc_hd__clkbuf_4
Xoutput77 net77 VGND VGND VPWR VPWR rdata[0] sky130_fd_sc_hd__clkbuf_4
Xoutput88 net88 VGND VGND VPWR VPWR rdata[1] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4270_ clknet_leaf_37_clk _0496_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_3221_ _1559_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__clkbuf_1
X_3152_ _1523_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__clkbuf_1
X_2103_ net15 net693 _0855_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3083_ _1486_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2034_ _0819_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3985_ clknet_leaf_40_clk net356 VGND VGND VPWR VPWR instance_1.rdata\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2936_ _1408_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__clkbuf_1
X_2867_ _1372_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2798_ _1336_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__clkbuf_1
Xhold310 instance_0.mem\[1\]\[19\] VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__dlygate4sd3_1
Xhold332 instance_1.rdata\[60\] VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold343 instance_1.mem\[2\]\[51\] VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__dlygate4sd3_1
Xhold321 instance_0.mem\[0\]\[51\] VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__dlygate4sd3_1
Xhold354 instance_0.mem\[1\]\[43\] VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__dlygate4sd3_1
Xhold387 instance_1.mem\[3\]\[13\] VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__dlygate4sd3_1
Xhold376 instance_1.mem\[0\]\[14\] VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__dlygate4sd3_1
Xhold365 instance_1.mem\[3\]\[62\] VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__dlygate4sd3_1
X_4468_ clknet_leaf_5_clk _0694_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3419_ net778 net59 _1659_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold398 instance_1.mem\[0\]\[6\] VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__dlygate4sd3_1
X_4399_ clknet_leaf_53_clk _0625_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_56_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3770_ net409 net24 _0805_ VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__mux2_1
X_2721_ instance_1.mem\[1\]\[48\] _1244_ _0957_ instance_1.mem\[3\]\[48\] _1263_ VGND
+ VGND VPWR VPWR _1284_ sky130_fd_sc_hd__a221o_1
XFILLER_0_81_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2652_ instance_1.mem\[0\]\[28\] instance_1.mem\[1\]\[28\] instance_1.mem\[2\]\[28\]
+ instance_1.mem\[3\]\[28\] _1202_ _1130_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__mux4_1
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2583_ instance_1.mem\[3\]\[9\] _1184_ _1105_ instance_1.mem\[2\]\[9\] VGND VGND
+ VPWR VPWR _1185_ sky130_fd_sc_hd__a22o_1
X_4322_ clknet_leaf_51_clk _0548_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_4253_ clknet_leaf_53_clk _0479_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3204_ _1550_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__clkbuf_1
X_4184_ clknet_leaf_51_clk _0410_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_3135_ _1514_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__clkbuf_1
X_3066_ _1477_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2017_ _0810_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_25_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3968_ clknet_leaf_49_clk net300 VGND VGND VPWR VPWR instance_1.rdata\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_61_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2919_ _1399_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3899_ clknet_leaf_49_clk net204 VGND VGND VPWR VPWR instance_0.rdata\[11\] sky130_fd_sc_hd__dfxtp_1
Xhold151 instance_1.rdata\[8\] VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlygate4sd3_1
Xhold162 _0143_ VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__dlygate4sd3_1
Xhold140 _0216_ VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__dlygate4sd3_1
Xhold195 instance_1.rdata\[33\] VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__dlygate4sd3_1
Xhold173 instance_1.rdata\[49\] VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlygate4sd3_1
Xhold184 _0130_ VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_83_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3822_ clknet_leaf_55_clk _0048_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3753_ _1840_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__clkbuf_1
X_2704_ instance_1.mem\[1\]\[43\] _1224_ _1177_ instance_1.mem\[3\]\[43\] VGND VGND
+ VPWR VPWR _1272_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_30_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3684_ _1804_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__clkbuf_1
X_2635_ instance_1.mem\[0\]\[23\] _0963_ _1166_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2566_ instance_1.mem\[1\]\[5\] _0939_ _1166_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__a21o_1
X_4305_ clknet_leaf_12_clk _0531_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_2497_ _0938_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__buf_4
X_4236_ clknet_leaf_57_clk _0462_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[60\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4167_ clknet_leaf_52_clk _0393_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_3118_ _1505_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__clkbuf_1
X_4098_ clknet_leaf_1_clk _0324_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[66\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_38_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3049_ _1468_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_81_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_72_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2420_ net201 _1056_ _1064_ _1065_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__o22a_1
XFILLER_0_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2351_ net891 _1014_ _0936_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__mux2_1
X_2282_ _0962_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__buf_4
X_4021_ clknet_leaf_3_clk net232 VGND VGND VPWR VPWR instance_1.rdata\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1997_ _0797_ VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__buf_1
X_3805_ clknet_leaf_2_clk _0031_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[61\] sky130_fd_sc_hd__dfxtp_1
X_3736_ _1831_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__clkbuf_1
X_3667_ net49 net780 _1795_ VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__mux2_1
X_3598_ _1759_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__clkbuf_1
X_2618_ net438 _1210_ _1188_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__mux2_1
X_2549_ net519 _1156_ _1159_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__mux2_1
X_4219_ clknet_leaf_25_clk _0445_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[43\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1920_ _0757_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__buf_1
X_1851_ net3 VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_40_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3521_ _1718_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__clkbuf_1
Xhold728 instance_0.mem\[0\]\[52\] VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__dlygate4sd3_1
Xhold717 instance_1.mem\[1\]\[16\] VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold706 instance_1.mem\[0\]\[63\] VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3452_ _1682_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__clkbuf_1
Xhold739 instance_0.mem\[2\]\[27\] VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__dlygate4sd3_1
X_3383_ _1645_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__clkbuf_1
X_2403_ net183 _1024_ _1051_ _1053_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__o22a_1
X_2334_ _1002_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__clkbuf_1
X_2265_ net1 net2 VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__and2b_1
X_2196_ _0905_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__clkbuf_1
X_4004_ clknet_leaf_24_clk net246 VGND VGND VPWR VPWR instance_1.rdata\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3719_ _1822_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__clkbuf_1
Xhold11 instance_0.rdata\[12\] VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 _0136_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 _0122_ VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 instance_0.rdata\[17\] VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 instance_0.rdata\[11\] VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 instance_1.rdata\[7\] VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 _0118_ VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 _0137_ VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 instance_0.rdata\[31\] VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_8 _1145_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2050_ _0827_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2952_ net15 net850 _1416_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1903_ _0748_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__buf_1
X_2883_ net39 net789 _1379_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3504_ _1709_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__clkbuf_1
Xhold503 instance_0.mem\[0\]\[36\] VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4484_ clknet_leaf_36_clk _0710_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[20\] sky130_fd_sc_hd__dfxtp_1
Xhold514 instance_1.mem\[1\]\[20\] VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__dlygate4sd3_1
Xhold525 instance_1.mem\[3\]\[24\] VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__dlygate4sd3_1
Xhold536 instance_0.mem\[3\]\[55\] VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__dlygate4sd3_1
Xhold558 instance_1.mem\[3\]\[44\] VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__dlygate4sd3_1
X_3435_ _1673_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__clkbuf_1
Xhold569 instance_1.mem\[1\]\[26\] VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__dlygate4sd3_1
Xhold547 instance_0.mem\[2\]\[31\] VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__dlygate4sd3_1
X_3366_ _1636_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__clkbuf_1
X_2317_ net301 _0937_ _0987_ _0989_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__o22a_1
X_3297_ _1577_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__buf_4
X_2248_ _0932_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_73_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2179_ _0896_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_51_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput78 net78 VGND VGND VPWR VPWR rdata[10] sky130_fd_sc_hd__clkbuf_4
Xoutput89 net89 VGND VGND VPWR VPWR rdata[20] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3220_ net786 net55 _1552_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__mux2_1
X_3151_ net479 net19 _1519_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__mux2_1
X_2102_ _0856_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3082_ net63 net500 _1482_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__mux2_1
X_2033_ net484 net39 _0817_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3984_ clknet_leaf_35_clk net330 VGND VGND VPWR VPWR instance_1.rdata\[24\] sky130_fd_sc_hd__dfxtp_1
X_2935_ net66 net711 _1401_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2866_ net30 net967 _1368_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__mux2_1
Xhold311 instance_0.mem\[3\]\[10\] VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__dlygate4sd3_1
X_2797_ net4 net715 _1335_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold300 instance_1.mem\[3\]\[71\] VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__dlygate4sd3_1
Xhold344 instance_1.rdata\[69\] VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold333 instance_1.mem\[1\]\[62\] VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__dlygate4sd3_1
Xhold322 instance_0.mem\[3\]\[21\] VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__dlygate4sd3_1
X_4467_ clknet_leaf_52_clk _0693_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
Xhold377 instance_1.mem\[1\]\[61\] VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__dlygate4sd3_1
Xhold355 instance_0.mem\[3\]\[25\] VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__dlygate4sd3_1
Xhold366 instance_1.mem\[3\]\[47\] VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__dlygate4sd3_1
X_4398_ clknet_leaf_54_clk _0624_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xhold388 instance_1.mem\[2\]\[12\] VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__dlygate4sd3_1
X_3418_ _1664_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__clkbuf_1
Xhold399 instance_1.mem\[1\]\[18\] VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__dlygate4sd3_1
X_3349_ _1627_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_56_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2720_ instance_1.mem\[0\]\[48\] _1190_ _1248_ instance_1.mem\[2\]\[48\] VGND VGND
+ VPWR VPWR _1283_ sky130_fd_sc_hd__a22o_1
X_2651_ net369 _1232_ _1233_ _1234_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__o22a_1
X_2582_ _0956_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__buf_4
X_4321_ clknet_leaf_54_clk _0547_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4252_ clknet_leaf_52_clk _0478_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3203_ net803 net46 _1541_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__mux2_1
X_4183_ clknet_leaf_47_clk _0409_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3134_ net594 net10 _1508_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__mux2_1
X_3065_ net54 net557 _1471_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2016_ net766 net30 _0806_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3967_ clknet_leaf_47_clk net248 VGND VGND VPWR VPWR instance_1.rdata\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_61_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2918_ net57 net691 _1390_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_30_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_30_clk sky130_fd_sc_hd__clkbuf_8
X_3898_ clknet_leaf_45_clk net302 VGND VGND VPWR VPWR instance_0.rdata\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2849_ net21 net640 _1357_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold152 _0194_ VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__dlygate4sd3_1
Xhold130 _0134_ VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__dlygate4sd3_1
Xhold141 instance_1.rdata\[57\] VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__dlygate4sd3_1
Xhold163 instance_1.rdata\[41\] VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__dlygate4sd3_1
Xhold185 instance_0.rdata\[44\] VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__dlygate4sd3_1
Xhold174 _0235_ VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlygate4sd3_1
Xhold196 _0219_ VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_69_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_21_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_21_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_63_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3821_ clknet_leaf_53_clk _0047_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3752_ net595 net14 _1838_ VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_12_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_8
X_2703_ net295 _1261_ _1270_ _1271_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_30_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3683_ net57 net945 _1795_ VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2634_ instance_1.mem\[1\]\[23\] _1102_ _0978_ instance_1.mem\[2\]\[23\] _1221_ VGND
+ VGND VPWR VPWR _1222_ sky130_fd_sc_hd__a221o_1
X_2565_ net217 _1163_ _1170_ _1171_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__o22a_1
X_4304_ clknet_leaf_8_clk _0530_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_2496_ instance_0.mem\[0\]\[58\] _1042_ _1105_ instance_0.mem\[2\]\[58\] VGND VGND
+ VPWR VPWR _1121_ sky130_fd_sc_hd__a22o_1
X_4235_ clknet_leaf_11_clk _0461_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4166_ clknet_leaf_1_clk _0392_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_3117_ net569 net73 _1497_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4097_ clknet_leaf_0_clk _0323_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[65\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_38_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3048_ net45 net928 _1460_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_23_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2350_ instance_0.mem\[0\]\[19\] instance_0.mem\[1\]\[19\] instance_0.mem\[2\]\[19\]
+ instance_0.mem\[3\]\[19\] _0973_ _0974_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_9_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2281_ _0946_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__clkbuf_4
X_4020_ clknet_leaf_0_clk _0246_ VGND VGND VPWR VPWR instance_1.rdata\[60\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_1_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_32_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3804_ clknet_leaf_57_clk _0030_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_1996_ instance_0.rdata\[68\] instance_1.rdata\[68\] _0788_ VGND VGND VPWR VPWR _0797_
+ sky130_fd_sc_hd__mux2_1
X_3735_ net916 net6 _1827_ VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_41_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3666_ _1739_ VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__buf_4
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3597_ net12 net901 _1751_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__mux2_1
X_2617_ instance_1.mem\[0\]\[18\] instance_1.mem\[1\]\[18\] instance_1.mem\[2\]\[18\]
+ instance_1.mem\[3\]\[18\] _1202_ _1130_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__mux4_1
X_2548_ _1158_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__buf_4
X_4218_ clknet_leaf_17_clk _0444_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[42\] sky130_fd_sc_hd__dfxtp_1
X_2479_ instance_0.mem\[1\]\[53\] _1021_ _1108_ instance_0.mem\[3\]\[53\] VGND VGND
+ VPWR VPWR _1109_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_50_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4149_ clknet_leaf_14_clk _0375_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3520_ net846 net52 _1714_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__mux2_1
Xhold707 instance_0.mem\[0\]\[70\] VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__dlygate4sd3_1
Xhold718 instance_0.mem\[2\]\[28\] VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__dlygate4sd3_1
X_3451_ net881 net16 _1681_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__mux2_1
Xhold729 instance_1.mem\[0\]\[20\] VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__dlygate4sd3_1
X_3382_ net461 net60 _1644_ VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__mux2_1
X_2402_ instance_0.mem\[1\]\[32\] _1010_ _1048_ instance_0.mem\[0\]\[32\] _1052_ VGND
+ VGND VPWR VPWR _1053_ sky130_fd_sc_hd__a221o_1
X_2333_ net394 _1001_ _0936_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__mux2_1
X_2264_ _0946_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__buf_4
X_4003_ clknet_leaf_25_clk net164 VGND VGND VPWR VPWR instance_1.rdata\[43\] sky130_fd_sc_hd__dfxtp_1
X_2195_ net43 net623 _0899_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_48_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1979_ _0721_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__buf_4
XFILLER_0_15_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3718_ net565 net37 _0850_ VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__mux2_1
X_3649_ _1786_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold23 instance_1.rdata\[39\] VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 _0126_ VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 instance_1.rdata\[35\] VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold34 _0131_ VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 _0125_ VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dlygate4sd3_1
Xhold89 instance_0.rdata\[42\] VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 instance_1.rdata\[3\] VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 _0145_ VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_9 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2951_ _1417_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1902_ instance_0.rdata\[23\] instance_1.rdata\[23\] _0744_ VGND VGND VPWR VPWR _0748_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2882_ _1380_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__clkbuf_1
X_3503_ net387 net43 _1703_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__mux2_1
Xhold504 instance_1.mem\[1\]\[34\] VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__dlygate4sd3_1
Xhold515 instance_1.mem\[3\]\[36\] VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__dlygate4sd3_1
X_4483_ clknet_leaf_40_clk _0709_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold526 instance_1.mem\[3\]\[55\] VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__dlygate4sd3_1
Xhold559 instance_0.mem\[2\]\[52\] VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__dlygate4sd3_1
Xhold537 instance_0.mem\[2\]\[69\] VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__dlygate4sd3_1
X_3434_ net390 net7 _1670_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold548 instance_1.mem\[0\]\[55\] VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__dlygate4sd3_1
X_3365_ net842 net51 _1633_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__mux2_1
X_2316_ instance_0.mem\[1\]\[10\] _0965_ _0988_ instance_0.mem\[3\]\[10\] _0960_ VGND
+ VGND VPWR VPWR _0989_ sky130_fd_sc_hd__a221o_1
X_3296_ _1599_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__clkbuf_1
X_2247_ net71 net855 _0854_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2178_ net34 net955 _0888_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput79 net79 VGND VGND VPWR VPWR rdata[11] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3150_ _1522_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__clkbuf_1
X_2101_ net4 net875 _0855_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__mux2_1
X_3081_ _1485_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__clkbuf_1
X_2032_ _0818_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3983_ clknet_leaf_36_clk net316 VGND VGND VPWR VPWR instance_1.rdata\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2934_ _1407_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__clkbuf_1
X_2865_ _1371_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold301 instance_1.mem\[3\]\[41\] VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__dlygate4sd3_1
X_2796_ _1334_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__buf_4
Xhold312 instance_1.mem\[3\]\[38\] VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__dlygate4sd3_1
Xhold334 instance_1.mem\[3\]\[67\] VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__dlygate4sd3_1
Xhold323 instance_0.mem\[3\]\[62\] VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__dlygate4sd3_1
Xhold345 instance_1.mem\[2\]\[35\] VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__dlygate4sd3_1
Xhold356 instance_1.rdata\[1\] VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__dlygate4sd3_1
Xhold378 instance_0.mem\[2\]\[12\] VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__dlygate4sd3_1
X_4466_ clknet_leaf_50_clk _0692_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_68_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold367 instance_1.mem\[2\]\[33\] VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__dlygate4sd3_1
X_4397_ clknet_leaf_53_clk _0623_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3417_ net553 net48 _1659_ VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__mux2_1
Xhold389 instance_1.mem\[2\]\[32\] VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__dlygate4sd3_1
X_3348_ net898 net42 _1622_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3279_ net517 net6 _1589_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_56_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_79_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_88_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2650_ instance_1.mem\[1\]\[27\] _1192_ _1071_ instance_1.mem\[3\]\[27\] _1230_ VGND
+ VGND VPWR VPWR _1234_ sky130_fd_sc_hd__a221o_1
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2581_ net299 _1163_ _1180_ _1183_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__o22a_1
X_4320_ clknet_leaf_54_clk _0546_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4251_ clknet_leaf_52_clk _0477_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_3202_ _1549_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__clkbuf_1
X_4182_ clknet_leaf_55_clk _0408_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3133_ _1513_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__clkbuf_1
X_3064_ _1476_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__clkbuf_1
X_2015_ _0809_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3966_ clknet_leaf_55_clk _0192_ VGND VGND VPWR VPWR instance_1.rdata\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_61_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2917_ _1398_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3897_ clknet_leaf_50_clk net308 VGND VGND VPWR VPWR instance_0.rdata\[9\] sky130_fd_sc_hd__dfxtp_1
X_2848_ _1362_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__clkbuf_1
X_2779_ instance_1.mem\[0\]\[67\] instance_1.mem\[1\]\[67\] instance_1.mem\[2\]\[67\]
+ instance_1.mem\[3\]\[67\] _0944_ _1278_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold153 instance_0.rdata\[10\] VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__dlygate4sd3_1
Xhold120 _0202_ VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__dlygate4sd3_1
Xhold142 _0243_ VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__dlygate4sd3_1
Xhold131 instance_0.rdata\[48\] VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__dlygate4sd3_1
Xhold164 _0227_ VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__dlygate4sd3_1
Xhold186 _0158_ VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__dlygate4sd3_1
Xhold175 instance_1.rdata\[22\] VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__dlygate4sd3_1
X_4449_ clknet_leaf_7_clk _0675_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[57\] sky130_fd_sc_hd__dfxtp_1
Xhold197 instance_1.rdata\[12\] VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_69_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3820_ clknet_leaf_51_clk _0046_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3751_ _1839_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__clkbuf_1
X_2702_ instance_1.mem\[1\]\[42\] _1244_ _1086_ instance_1.mem\[0\]\[42\] _1263_ VGND
+ VGND VPWR VPWR _1271_ sky130_fd_sc_hd__a221o_1
XFILLER_0_15_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_30_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3682_ _1803_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__clkbuf_1
X_2633_ _0973_ _0945_ instance_1.mem\[3\]\[23\] VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__and3_1
XFILLER_0_2_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2564_ instance_1.mem\[0\]\[4\] _1145_ _1127_ instance_1.mem\[2\]\[4\] _1166_ VGND
+ VGND VPWR VPWR _1171_ sky130_fd_sc_hd__a221o_1
XFILLER_0_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4303_ clknet_leaf_12_clk _0529_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_2495_ net223 _1092_ _1119_ _1120_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__o22a_1
X_4234_ clknet_leaf_8_clk _0460_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4165_ clknet_leaf_2_clk _0391_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[61\] sky130_fd_sc_hd__dfxtp_1
X_3116_ _1504_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_66_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4096_ clknet_leaf_4_clk _0322_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[64\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_38_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3047_ _1467_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__clkbuf_1
X_3949_ clknet_leaf_3_clk _0175_ VGND VGND VPWR VPWR instance_0.rdata\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2280_ net297 _0937_ _0959_ _0961_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_9_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3803_ clknet_leaf_11_clk _0029_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_1995_ _0796_ VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3734_ _1830_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3665_ _1794_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__clkbuf_1
X_2616_ net351 _1205_ _1208_ _1209_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__o22a_1
XFILLER_0_30_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3596_ _1758_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2547_ _1157_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__buf_4
X_2478_ _0956_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__buf_4
X_4217_ clknet_leaf_16_clk _0443_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[41\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4148_ clknet_leaf_18_clk _0374_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[44\] sky130_fd_sc_hd__dfxtp_1
X_4079_ clknet_leaf_19_clk _0305_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_40_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold719 instance_1.mem\[0\]\[49\] VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold708 instance_0.mem\[0\]\[68\] VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__dlygate4sd3_1
X_3450_ _1658_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__buf_4
X_3381_ _1577_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__buf_4
X_2401_ _0951_ _0952_ instance_0.mem\[3\]\[32\] VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__and3_1
X_2332_ instance_0.mem\[0\]\[14\] instance_0.mem\[1\]\[14\] instance_0.mem\[2\]\[14\]
+ instance_0.mem\[3\]\[14\] _0973_ _0974_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__mux4_1
X_4002_ clknet_leaf_17_clk net296 VGND VGND VPWR VPWR instance_1.rdata\[42\] sky130_fd_sc_hd__dfxtp_1
X_2263_ _0944_ _0945_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__nor2_2
X_2194_ _0904_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_48_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3717_ _1821_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__clkbuf_1
X_1978_ _0787_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__clkbuf_1
X_3648_ net39 net849 _1784_ VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__mux2_1
X_3579_ _1749_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold13 instance_0.rdata\[54\] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 _0221_ VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 _0225_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 instance_0.rdata\[32\] VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 instance_1.rdata\[36\] VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold68 _0189_ VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 instance_0.rdata\[2\] VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2950_ net4 net931 _1416_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__mux2_1
X_1901_ _0747_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__buf_1
X_2881_ net38 net763 _1379_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__mux2_1
Xhold505 instance_1.mem\[0\]\[38\] VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__dlygate4sd3_1
Xhold516 instance_0.mem\[1\]\[35\] VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__dlygate4sd3_1
X_3502_ _1708_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__clkbuf_1
Xhold527 instance_0.mem\[1\]\[4\] VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__dlygate4sd3_1
X_4482_ clknet_leaf_38_clk _0708_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xhold538 instance_0.mem\[1\]\[6\] VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__dlygate4sd3_1
X_3433_ _1672_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold549 instance_0.mem\[2\]\[40\] VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__dlygate4sd3_1
X_3364_ _1635_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__clkbuf_1
X_3295_ net731 net14 _1589_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__mux2_1
X_2315_ _0956_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__clkbuf_8
X_2246_ _0931_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2177_ _0895_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_51_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3080_ net62 net823 _1482_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__mux2_1
X_2100_ _0854_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__buf_4
X_2031_ net375 net38 _0817_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3982_ clknet_leaf_37_clk net324 VGND VGND VPWR VPWR instance_1.rdata\[22\] sky130_fd_sc_hd__dfxtp_1
X_2933_ net65 net851 _1401_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2864_ net29 net843 _1368_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2795_ _1333_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__buf_4
Xhold302 instance_1.mem\[1\]\[69\] VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__dlygate4sd3_1
Xhold335 instance_1.mem\[3\]\[45\] VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__dlygate4sd3_1
Xhold313 instance_1.mem\[2\]\[60\] VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold324 instance_1.mem\[2\]\[23\] VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__dlygate4sd3_1
Xhold368 instance_0.mem\[3\]\[15\] VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__dlygate4sd3_1
X_4465_ clknet_leaf_54_clk _0691_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold357 instance_0.mem\[0\]\[59\] VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__dlygate4sd3_1
Xhold346 instance_1.mem\[2\]\[30\] VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__dlygate4sd3_1
Xhold379 instance_1.mem\[1\]\[52\] VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__dlygate4sd3_1
X_3416_ _1663_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4396_ clknet_leaf_52_clk _0622_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_68_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3347_ _1626_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3278_ _1590_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__clkbuf_1
X_2229_ net61 net509 _0921_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_56_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2580_ instance_1.mem\[1\]\[8\] _1122_ _1181_ instance_1.mem\[2\]\[8\] _1182_ VGND
+ VGND VPWR VPWR _1183_ sky130_fd_sc_hd__a221o_1
XFILLER_0_22_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4250_ clknet_leaf_50_clk _0476_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_4181_ clknet_leaf_51_clk _0407_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3201_ net514 net45 _1541_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__mux2_1
X_3132_ net440 net9 _1508_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__mux2_1
X_3063_ net53 net643 _1471_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2014_ net694 net29 _0806_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3965_ clknet_leaf_53_clk net282 VGND VGND VPWR VPWR instance_1.rdata\[5\] sky130_fd_sc_hd__dfxtp_1
X_3896_ clknet_leaf_48_clk net192 VGND VGND VPWR VPWR instance_0.rdata\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_61_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2916_ net56 net726 _1390_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2847_ net20 net903 _1357_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2778_ net257 _1295_ _1321_ _1322_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__o22a_1
Xhold110 _0252_ VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold121 instance_0.rdata\[18\] VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__dlygate4sd3_1
Xhold143 instance_1.rdata\[68\] VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__dlygate4sd3_1
Xhold132 _0162_ VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__dlygate4sd3_1
Xhold154 _0124_ VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__dlygate4sd3_1
Xhold176 _0208_ VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__dlygate4sd3_1
X_4448_ clknet_leaf_8_clk _0674_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[56\] sky130_fd_sc_hd__dfxtp_1
Xhold165 instance_1.rdata\[59\] VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlygate4sd3_1
Xhold198 _0198_ VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__dlygate4sd3_1
Xhold187 instance_1.rdata\[58\] VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__dlygate4sd3_1
X_4379_ clknet_leaf_10_clk _0605_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[59\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_69_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3750_ net547 net13 _1838_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2701_ instance_1.mem\[3\]\[42\] _0988_ _1248_ instance_1.mem\[2\]\[42\] VGND VGND
+ VPWR VPWR _1270_ sky130_fd_sc_hd__a22o_1
XFILLER_0_27_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_30_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3681_ net56 net912 _1795_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2632_ net323 _1205_ _1219_ _1220_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__o22a_1
XFILLER_0_2_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2563_ instance_1.mem\[1\]\[4\] _1111_ _1108_ instance_1.mem\[3\]\[4\] VGND VGND
+ VPWR VPWR _1170_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4302_ clknet_leaf_10_clk _0528_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4233_ clknet_leaf_12_clk _0459_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_2494_ instance_0.mem\[1\]\[57\] _1058_ _1048_ instance_0.mem\[0\]\[57\] _1074_ VGND
+ VGND VPWR VPWR _1120_ sky130_fd_sc_hd__a221o_1
X_4164_ clknet_leaf_1_clk _0390_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_3115_ net521 net70 _1497_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4095_ clknet_leaf_4_clk _0321_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[63\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3046_ net44 net637 _1460_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3948_ clknet_leaf_0_clk net254 VGND VGND VPWR VPWR instance_0.rdata\[60\] sky130_fd_sc_hd__dfxtp_1
X_3879_ clknet_leaf_4_clk _0105_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[63\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3802_ clknet_leaf_6_clk _0028_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1994_ instance_0.rdata\[67\] instance_1.rdata\[67\] _0788_ VGND VGND VPWR VPWR _0796_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3733_ net401 net5 _1827_ VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3664_ net47 net867 _1784_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__mux2_1
X_2615_ instance_1.mem\[1\]\[17\] _1192_ _1154_ instance_1.mem\[0\]\[17\] _1193_ VGND
+ VGND VPWR VPWR _1209_ sky130_fd_sc_hd__a221o_1
X_3595_ net11 net905 _1751_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2546_ _0720_ _0801_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__and2_1
X_2477_ net179 _1092_ _1106_ _1107_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__o22a_1
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4216_ clknet_leaf_21_clk _0442_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_4147_ clknet_leaf_17_clk _0373_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[43\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4078_ clknet_leaf_19_clk _0304_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_3029_ net35 net762 _1449_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold709 instance_1.mem\[2\]\[27\] VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2400_ instance_0.mem\[2\]\[32\] _0986_ _0942_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__a21o_1
X_3380_ _1643_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2331_ net233 _0990_ _0998_ _1000_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__o22a_1
X_2262_ net2 VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__clkbuf_4
X_4001_ clknet_leaf_17_clk net312 VGND VGND VPWR VPWR instance_1.rdata\[41\] sky130_fd_sc_hd__dfxtp_1
X_2193_ net42 net872 _0899_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3716_ net579 net26 _0850_ VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__mux2_1
X_1977_ instance_0.rdata\[59\] instance_1.rdata\[59\] _0777_ VGND VGND VPWR VPWR _0787_
+ sky130_fd_sc_hd__mux2_1
X_3647_ _1785_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__clkbuf_1
X_3578_ net74 net808 _1740_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__mux2_1
X_2529_ _0946_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__buf_4
Xhold14 _0168_ VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 instance_0.rdata\[35\] VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 instance_0.rdata\[21\] VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 _0146_ VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold69 instance_1.rdata\[4\] VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dlygate4sd3_1
Xhold58 _0116_ VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1900_ instance_0.rdata\[22\] instance_1.rdata\[22\] _0744_ VGND VGND VPWR VPWR _0747_
+ sky130_fd_sc_hd__mux2_1
X_2880_ _1334_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__buf_4
XFILLER_0_84_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3501_ net940 net42 _1703_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__mux2_1
X_4481_ clknet_leaf_41_clk _0707_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[17\] sky130_fd_sc_hd__dfxtp_1
Xhold517 instance_0.mem\[3\]\[61\] VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold506 instance_1.mem\[0\]\[31\] VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__dlygate4sd3_1
Xhold528 instance_0.mem\[2\]\[43\] VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__dlygate4sd3_1
Xhold539 instance_0.mem\[1\]\[52\] VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__dlygate4sd3_1
X_3432_ net760 net6 _1670_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__mux2_1
X_3363_ net491 net50 _1633_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__mux2_1
X_2314_ instance_0.mem\[0\]\[10\] _0963_ _0986_ instance_0.mem\[2\]\[10\] VGND VGND
+ VPWR VPWR _0987_ sky130_fd_sc_hd__a22o_1
X_3294_ _1598_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__clkbuf_1
X_2245_ net69 net911 _0921_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__mux2_1
X_2176_ net33 net651 _0888_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_51_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_51_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_66_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2030_ _0805_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__buf_4
XFILLER_0_89_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3981_ clknet_leaf_40_clk net362 VGND VGND VPWR VPWR instance_1.rdata\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2932_ _1406_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_42_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_42_clk sky130_fd_sc_hd__clkbuf_8
X_2863_ _1370_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__clkbuf_1
X_2794_ _0720_ _0801_ _0803_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__or3b_1
XFILLER_0_80_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold314 instance_1.mem\[0\]\[65\] VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__dlygate4sd3_1
Xhold303 instance_1.mem\[3\]\[12\] VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold325 instance_1.rdata\[28\] VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__dlygate4sd3_1
Xhold336 instance_1.mem\[1\]\[41\] VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold347 instance_1.mem\[0\]\[60\] VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__dlygate4sd3_1
Xhold358 instance_1.rdata\[15\] VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4464_ clknet_leaf_54_clk _0690_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xhold369 instance_1.mem\[2\]\[11\] VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__dlygate4sd3_1
X_3415_ net860 net37 _1659_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__mux2_1
X_4395_ clknet_leaf_52_clk _0621_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3346_ net650 net41 _1622_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__mux2_1
X_3277_ net418 net5 _1589_ VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__mux2_1
X_2228_ _0922_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_56_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2159_ net24 net946 _0877_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__mux2_1
XFILLER_0_67_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_33_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_33_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_31_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_24_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_24_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_27_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4180_ clknet_leaf_52_clk _0406_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3200_ _1548_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__clkbuf_1
X_3131_ _1512_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__clkbuf_1
X_3062_ _1475_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__clkbuf_1
X_2013_ _0808_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_15_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_8
X_3964_ clknet_leaf_52_clk net218 VGND VGND VPWR VPWR instance_1.rdata\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_85_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3895_ clknet_leaf_48_clk net242 VGND VGND VPWR VPWR instance_0.rdata\[7\] sky130_fd_sc_hd__dfxtp_1
X_2915_ _1397_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_61_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2846_ _1361_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold100 _0193_ VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__dlygate4sd3_1
X_2777_ instance_1.mem\[0\]\[66\] _1252_ _1103_ instance_1.mem\[2\]\[66\] _1297_ VGND
+ VGND VPWR VPWR _1322_ sky130_fd_sc_hd__a221o_1
Xhold133 instance_1.rdata\[5\] VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__dlygate4sd3_1
Xhold122 _0132_ VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__dlygate4sd3_1
Xhold144 _0254_ VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__dlygate4sd3_1
Xhold111 instance_1.rdata\[29\] VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__dlygate4sd3_1
Xhold155 instance_1.rdata\[70\] VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlygate4sd3_1
Xhold177 instance_0.rdata\[53\] VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__dlygate4sd3_1
Xhold166 _0245_ VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlygate4sd3_1
X_4447_ clknet_leaf_12_clk _0673_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[55\] sky130_fd_sc_hd__dfxtp_1
Xhold188 _0244_ VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__dlygate4sd3_1
Xhold199 instance_0.rdata\[27\] VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__dlygate4sd3_1
X_4378_ clknet_leaf_7_clk _0604_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[58\] sky130_fd_sc_hd__dfxtp_1
X_3329_ net493 net32 _1611_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_69_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2700_ net311 _1261_ _1268_ _1269_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__o22a_1
X_3680_ _1802_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2631_ instance_1.mem\[0\]\[22\] _1145_ _1181_ instance_1.mem\[2\]\[22\] _1193_ VGND
+ VGND VPWR VPWR _1220_ sky130_fd_sc_hd__a221o_1
XFILLER_0_2_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2562_ net215 _1163_ _1168_ _1169_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__o22a_1
X_4301_ clknet_leaf_11_clk _0527_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_4232_ clknet_leaf_8_clk _0458_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_2493_ instance_0.mem\[3\]\[57\] _1016_ _1105_ instance_0.mem\[2\]\[57\] VGND VGND
+ VPWR VPWR _1119_ sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_4_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_8
X_4163_ clknet_leaf_10_clk _0389_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_3114_ _1503_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__clkbuf_1
X_4094_ clknet_leaf_4_clk _0320_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_3045_ _1466_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_66_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3947_ clknet_leaf_11_clk _0173_ VGND VGND VPWR VPWR instance_0.rdata\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3878_ clknet_leaf_4_clk _0104_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_2829_ _1352_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_3_7__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_87_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_71_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3801_ clknet_leaf_7_clk _0027_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_1993_ _0795_ VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3732_ _1829_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__clkbuf_1
X_3663_ _1793_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__clkbuf_1
X_2614_ instance_1.mem\[3\]\[17\] _1184_ _1197_ instance_1.mem\[2\]\[17\] VGND VGND
+ VPWR VPWR _1208_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3594_ _1757_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_10_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2545_ instance_1.mem\[0\]\[0\] instance_1.mem\[1\]\[0\] instance_1.mem\[2\]\[0\]
+ instance_1.mem\[3\]\[0\] _1082_ _1130_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__mux4_1
X_2476_ instance_0.mem\[1\]\[52\] _1058_ _1048_ instance_0.mem\[0\]\[52\] _1074_ VGND
+ VGND VPWR VPWR _1107_ sky130_fd_sc_hd__a221o_1
X_4215_ clknet_leaf_26_clk _0441_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[39\] sky130_fd_sc_hd__dfxtp_1
X_4146_ clknet_leaf_17_clk _0372_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[42\] sky130_fd_sc_hd__dfxtp_1
X_4077_ clknet_leaf_16_clk _0303_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3028_ _1457_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2330_ instance_0.mem\[1\]\[13\] _0965_ _0988_ instance_0.mem\[3\]\[13\] _0999_ VGND
+ VGND VPWR VPWR _1000_ sky130_fd_sc_hd__a221o_1
XFILLER_0_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2261_ net1 VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__buf_4
X_4000_ clknet_leaf_21_clk net154 VGND VGND VPWR VPWR instance_1.rdata\[40\] sky130_fd_sc_hd__dfxtp_1
X_2192_ _0903_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1976_ _0786_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_1
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3715_ _1820_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3646_ net38 net597 _1784_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3577_ _1748_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__clkbuf_1
X_2528_ instance_0.mem\[1\]\[67\] _1111_ _1105_ instance_0.mem\[2\]\[67\] VGND VGND
+ VPWR VPWR _1144_ sky130_fd_sc_hd__a22o_1
Xhold15 instance_1.rdata\[43\] VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 instance_0.rdata\[65\] VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 _0135_ VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dlygate4sd3_1
X_2459_ _0951_ _0952_ instance_0.mem\[3\]\[48\] VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__and3_1
Xhold48 _0149_ VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__dlygate4sd3_1
Xhold59 instance_0.rdata\[49\] VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4129_ clknet_leaf_39_clk _0355_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_45_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3500_ _1707_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__clkbuf_1
X_4480_ clknet_leaf_45_clk _0706_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_25_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold507 instance_1.mem\[1\]\[66\] VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold518 instance_0.mem\[3\]\[47\] VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__dlygate4sd3_1
X_3431_ _1671_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__clkbuf_1
Xhold529 instance_1.mem\[3\]\[17\] VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__dlygate4sd3_1
X_3362_ _1634_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2313_ _0978_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__buf_4
X_3293_ net382 net13 _1589_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2244_ _0930_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2175_ _0894_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1959_ instance_0.rdata\[50\] instance_1.rdata\[50\] _0777_ VGND VGND VPWR VPWR _0778_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3629_ net29 net904 _1773_ VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3980_ clknet_leaf_36_clk net338 VGND VGND VPWR VPWR instance_1.rdata\[20\] sky130_fd_sc_hd__dfxtp_1
X_2931_ net64 net785 _1401_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2862_ net28 net810 _1368_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__mux2_1
X_2793_ _1332_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__clkbuf_1
Xhold326 instance_0.mem\[1\]\[45\] VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__dlygate4sd3_1
Xhold304 instance_1.mem\[1\]\[63\] VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__dlygate4sd3_1
Xhold315 instance_1.mem\[1\]\[6\] VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4463_ clknet_leaf_6_clk _0689_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[71\] sky130_fd_sc_hd__dfxtp_1
Xhold348 instance_1.mem\[2\]\[63\] VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__dlygate4sd3_1
Xhold337 instance_0.mem\[0\]\[19\] VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__dlygate4sd3_1
X_3414_ _1662_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold359 instance_1.mem\[2\]\[28\] VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4394_ clknet_leaf_50_clk _0620_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3345_ _1625_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3276_ _1577_ VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__buf_4
X_2227_ net60 net900 _0921_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2158_ _0885_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2089_ net680 net68 _0839_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_48_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_57_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3130_ net535 net8 _1508_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_66_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3061_ net52 net980 _1471_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2012_ net489 net28 _0806_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3963_ clknet_leaf_52_clk net216 VGND VGND VPWR VPWR instance_1.rdata\[3\] sky130_fd_sc_hd__dfxtp_1
X_3894_ clknet_leaf_55_clk _0120_ VGND VGND VPWR VPWR instance_0.rdata\[6\] sky130_fd_sc_hd__dfxtp_1
X_2914_ net55 net740 _1390_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_61_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_75_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2845_ net19 net943 _1357_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2776_ instance_1.mem\[1\]\[66\] _1224_ _0991_ instance_1.mem\[3\]\[66\] VGND VGND
+ VPWR VPWR _1321_ sky130_fd_sc_hd__a22o_1
XFILLER_0_41_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold101 instance_0.rdata\[28\] VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__dlygate4sd3_1
Xhold134 _0191_ VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__dlygate4sd3_1
Xhold123 instance_1.rdata\[54\] VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__dlygate4sd3_1
Xhold112 _0215_ VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__dlygate4sd3_1
Xhold145 instance_0.rdata\[64\] VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__dlygate4sd3_1
Xhold167 instance_1.rdata\[23\] VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlygate4sd3_1
X_4446_ clknet_leaf_9_clk _0672_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[54\] sky130_fd_sc_hd__dfxtp_1
Xhold156 _0256_ VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__dlygate4sd3_1
Xhold189 instance_1.rdata\[20\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__dlygate4sd3_1
Xhold178 _0167_ VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__dlygate4sd3_1
X_4377_ clknet_leaf_12_clk _0603_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[57\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_84_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3328_ _1616_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__clkbuf_1
X_3259_ _1580_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_24_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold690 instance_1.mem\[0\]\[48\] VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_59_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2630_ instance_1.mem\[1\]\[22\] _1111_ _1177_ instance_1.mem\[3\]\[22\] VGND VGND
+ VPWR VPWR _1219_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2561_ instance_1.mem\[1\]\[3\] _1122_ _1127_ instance_1.mem\[2\]\[3\] _1166_ VGND
+ VGND VPWR VPWR _1169_ sky130_fd_sc_hd__a221o_1
X_4300_ clknet_leaf_14_clk _0526_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[52\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2492_ net199 _1092_ _1116_ _1118_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__o22a_1
XFILLER_0_49_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4231_ clknet_leaf_13_clk _0457_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_4162_ clknet_leaf_8_clk _0388_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[58\] sky130_fd_sc_hd__dfxtp_1
X_3113_ net385 net59 _1497_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__mux2_1
X_4093_ clknet_leaf_2_clk _0319_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[61\] sky130_fd_sc_hd__dfxtp_1
X_3044_ net43 net589 _1460_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3946_ clknet_leaf_6_clk net262 VGND VGND VPWR VPWR instance_0.rdata\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3877_ clknet_leaf_2_clk _0103_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2828_ net10 net826 _1346_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__mux2_1
X_2759_ net480 _1309_ _1158_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__mux2_1
X_4429_ clknet_leaf_21_clk _0655_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[37\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3800_ clknet_leaf_8_clk _0026_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[56\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_71_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3731_ net572 net75 _1827_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__mux2_1
X_1992_ instance_0.rdata\[66\] instance_1.rdata\[66\] _0788_ VGND VGND VPWR VPWR _0795_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3662_ net46 net838 _1784_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__mux2_1
X_3593_ net10 net573 _1751_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__mux2_1
X_2613_ net267 _1205_ _1206_ _1207_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__o22a_1
XFILLER_0_11_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2544_ net263 _1089_ _1153_ _1155_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__o22a_1
X_2475_ instance_0.mem\[3\]\[52\] _1016_ _1105_ instance_0.mem\[2\]\[52\] VGND VGND
+ VPWR VPWR _1106_ sky130_fd_sc_hd__a22o_1
X_4214_ clknet_leaf_29_clk _0440_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_4145_ clknet_leaf_16_clk _0371_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[41\] sky130_fd_sc_hd__dfxtp_1
X_4076_ clknet_leaf_18_clk _0302_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[44\] sky130_fd_sc_hd__dfxtp_1
X_3027_ net34 net721 _1449_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3929_ clknet_leaf_17_clk net252 VGND VGND VPWR VPWR instance_0.rdata\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_61_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_6_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2260_ instance_0.mem\[1\]\[0\] _0939_ _0942_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__a21o_1
X_2191_ net41 net442 _0899_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_48_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1975_ instance_0.rdata\[58\] instance_1.rdata\[58\] _0777_ VGND VGND VPWR VPWR _0786_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3714_ net400 net15 _0850_ VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3645_ _1739_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__buf_4
X_3576_ net73 net795 _1740_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2527_ net209 _1089_ _1142_ _1143_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__o22a_1
XFILLER_0_11_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2458_ instance_0.mem\[2\]\[48\] _0986_ _0942_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold16 _0229_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 instance_0.rdata\[69\] VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 _0179_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__dlygate4sd3_1
Xhold49 instance_0.rdata\[3\] VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2389_ instance_0.mem\[0\]\[29\] _1042_ _1008_ instance_0.mem\[2\]\[29\] VGND VGND
+ VPWR VPWR _1043_ sky130_fd_sc_hd__a22o_1
X_4128_ clknet_leaf_33_clk _0354_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4059_ clknet_leaf_33_clk _0285_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_82_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold508 instance_0.mem\[3\]\[63\] VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__dlygate4sd3_1
Xhold519 instance_1.mem\[3\]\[30\] VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__dlygate4sd3_1
X_3430_ net459 net5 _1670_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3361_ net757 net49 _1633_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__mux2_1
X_2312_ net307 _0937_ _0984_ _0985_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__o22a_1
X_3292_ _1597_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2243_ net68 net856 _0921_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__mux2_1
X_2174_ net32 net631 _0888_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1958_ _0721_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__buf_4
X_1889_ instance_0.rdata\[17\] instance_1.rdata\[17\] _0733_ VGND VGND VPWR VPWR _0741_
+ sky130_fd_sc_hd__mux2_1
X_3628_ _1775_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__clkbuf_1
X_3559_ net76 net1 net2 net3 VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__or4b_1
XFILLER_0_11_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2930_ _1405_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2861_ _1369_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2792_ net529 _1331_ _1158_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__mux2_1
Xhold305 instance_1.rdata\[67\] VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__dlygate4sd3_1
Xhold316 instance_0.mem\[3\]\[16\] VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__dlygate4sd3_1
X_4462_ clknet_leaf_6_clk _0688_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[70\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3413_ net859 net26 _1659_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__mux2_1
Xhold338 instance_0.mem\[2\]\[18\] VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__dlygate4sd3_1
Xhold327 instance_1.mem\[2\]\[20\] VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__dlygate4sd3_1
Xhold349 instance_1.mem\[2\]\[40\] VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__dlygate4sd3_1
X_4393_ clknet_leaf_46_clk _0619_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3344_ net605 net40 _1622_ VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__mux2_1
X_3275_ _1588_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2226_ _0854_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__buf_4
XFILLER_0_84_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2157_ net23 net821 _0877_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__mux2_1
X_2088_ _0847_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3060_ _1474_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2011_ _0807_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3962_ clknet_leaf_50_clk net340 VGND VGND VPWR VPWR instance_1.rdata\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3893_ clknet_leaf_47_clk net328 VGND VGND VPWR VPWR instance_0.rdata\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2913_ _1396_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__clkbuf_1
X_2844_ _1360_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__clkbuf_1
X_2775_ _1320_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold135 instance_1.rdata\[13\] VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__dlygate4sd3_1
Xhold124 _0240_ VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__dlygate4sd3_1
Xhold113 instance_0.rdata\[58\] VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__dlygate4sd3_1
Xhold102 _0142_ VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold146 _0178_ VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__dlygate4sd3_1
Xhold168 _0209_ VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__dlygate4sd3_1
Xhold157 instance_0.rdata\[70\] VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__dlygate4sd3_1
X_4445_ clknet_leaf_11_clk _0671_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[53\] sky130_fd_sc_hd__dfxtp_1
Xhold179 instance_0.rdata\[5\] VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__dlygate4sd3_1
X_4376_ clknet_leaf_7_clk _0602_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_3327_ net432 net31 _1611_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__mux2_1
X_3258_ net511 net15 _1578_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__mux2_1
X_3189_ net449 net39 _1541_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__mux2_1
X_2209_ _0912_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_24_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold680 instance_0.mem\[2\]\[3\] VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold691 instance_0.mem\[1\]\[1\] VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_24_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2560_ instance_1.mem\[0\]\[3\] _1042_ _1108_ instance_1.mem\[3\]\[3\] VGND VGND
+ VPWR VPWR _1168_ sky130_fd_sc_hd__a22o_1
X_2491_ instance_0.mem\[1\]\[56\] _1058_ _1048_ instance_0.mem\[0\]\[56\] _1117_ VGND
+ VGND VPWR VPWR _1118_ sky130_fd_sc_hd__a221o_1
XFILLER_0_10_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4230_ clknet_leaf_10_clk _0456_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4161_ clknet_leaf_12_clk _0387_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_4092_ clknet_leaf_0_clk _0318_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_3112_ _1502_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__clkbuf_1
X_3043_ _1465_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_66_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3945_ clknet_leaf_15_clk net224 VGND VGND VPWR VPWR instance_0.rdata\[57\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_85_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3876_ clknet_leaf_1_clk _0102_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[60\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2827_ _1351_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2758_ instance_1.mem\[0\]\[60\] instance_1.mem\[1\]\[60\] instance_1.mem\[2\]\[60\]
+ instance_1.mem\[3\]\[60\] _1202_ _1278_ VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__mux4_1
X_4428_ clknet_leaf_27_clk _0654_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_2689_ _1159_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__buf_4
X_4359_ clknet_leaf_24_clk _0585_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1991_ _0794_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3730_ _1828_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_67_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3661_ _1792_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__clkbuf_1
X_2612_ instance_1.mem\[0\]\[16\] _1145_ _1181_ instance_1.mem\[2\]\[16\] _1193_ VGND
+ VGND VPWR VPWR _1207_ sky130_fd_sc_hd__a221o_1
X_3592_ _1756_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2543_ instance_0.mem\[1\]\[71\] _1122_ _1154_ instance_0.mem\[0\]\[71\] _1128_ VGND
+ VGND VPWR VPWR _1155_ sky130_fd_sc_hd__a221o_1
XFILLER_0_55_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2474_ _0978_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__buf_4
X_4213_ clknet_leaf_21_clk _0439_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_4144_ clknet_leaf_21_clk _0370_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[40\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4075_ clknet_leaf_24_clk _0301_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[43\] sky130_fd_sc_hd__dfxtp_1
X_3026_ _1456_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3928_ clknet_leaf_21_clk net230 VGND VGND VPWR VPWR instance_0.rdata\[40\] sky130_fd_sc_hd__dfxtp_1
X_3859_ clknet_leaf_24_clk _0085_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[43\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2190_ _0902_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_76_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1974_ _0785_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__buf_1
XFILLER_0_15_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3713_ _1819_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__clkbuf_1
X_3644_ _1783_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3575_ _1747_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__clkbuf_1
X_2526_ instance_0.mem\[1\]\[66\] _1122_ _1127_ instance_0.mem\[2\]\[66\] _1128_ VGND
+ VGND VPWR VPWR _1143_ sky130_fd_sc_hd__a221o_1
X_2457_ _0936_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__buf_4
Xhold17 instance_0.rdata\[15\] VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 _0183_ VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold39 instance_0.rdata\[67\] VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__dlygate4sd3_1
X_2388_ _0962_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__clkbuf_8
X_4127_ clknet_leaf_37_clk _0353_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4058_ clknet_leaf_33_clk _0284_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_3009_ _1447_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_45_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_54_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_54_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_57_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold509 instance_1.mem\[0\]\[62\] VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__dlygate4sd3_1
X_3360_ _1577_ VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__buf_4
X_2311_ instance_0.mem\[0\]\[9\] _0947_ _0979_ instance_0.mem\[2\]\[9\] _0960_ VGND
+ VGND VPWR VPWR _0985_ sky130_fd_sc_hd__a221o_1
X_3291_ net558 net12 _1589_ VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__mux2_1
X_2242_ _0929_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__clkbuf_1
X_2173_ _0893_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_45_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_45_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_75_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1957_ _0776_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1888_ _0740_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3627_ net28 net654 _1773_ VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__mux2_1
X_3558_ _1737_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2509_ instance_0.mem\[0\]\[61\] instance_0.mem\[1\]\[61\] instance_0.mem\[2\]\[61\]
+ instance_0.mem\[3\]\[61\] _1082_ _1130_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__mux4_1
X_3489_ _1701_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_36_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_36_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_50_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_27_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_27_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_43_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2860_ net27 net897 _1368_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2791_ instance_1.mem\[0\]\[71\] instance_1.mem\[1\]\[71\] instance_1.mem\[2\]\[71\]
+ instance_1.mem\[3\]\[71\] _0944_ _0952_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__mux4_1
XFILLER_0_13_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4461_ clknet_leaf_56_clk _0687_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[69\] sky130_fd_sc_hd__dfxtp_1
Xhold317 instance_1.mem\[2\]\[6\] VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__dlygate4sd3_1
Xhold306 instance_1.mem\[1\]\[17\] VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__dlygate4sd3_1
Xhold339 instance_1.mem\[2\]\[41\] VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__dlygate4sd3_1
X_3412_ _1661_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold328 instance_1.mem\[3\]\[58\] VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__dlygate4sd3_1
X_4392_ clknet_leaf_54_clk _0618_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3343_ _1624_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__clkbuf_1
X_3274_ net790 net75 _1578_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2225_ _0920_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__clkbuf_1
X_2156_ _0884_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_18_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_8
X_2087_ net404 net67 _0839_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2989_ net14 net508 _1427_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2010_ net809 net27 _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3961_ clknet_leaf_46_clk _0187_ VGND VGND VPWR VPWR instance_1.rdata\[1\] sky130_fd_sc_hd__dfxtp_1
X_2912_ net54 net604 _1390_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__mux2_1
X_3892_ clknet_leaf_51_clk net214 VGND VGND VPWR VPWR instance_0.rdata\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2843_ net18 net831 _1357_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2774_ net436 _1319_ _1158_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold103 instance_0.rdata\[41\] VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__dlygate4sd3_1
Xhold114 _0172_ VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__dlygate4sd3_1
Xhold125 instance_1.rdata\[48\] VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__dlygate4sd3_1
Xhold147 instance_1.rdata\[42\] VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__dlygate4sd3_1
X_4444_ clknet_leaf_14_clk _0670_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[52\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold136 _0199_ VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__dlygate4sd3_1
Xhold158 _0184_ VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_7_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_8
Xhold169 instance_1.rdata\[56\] VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__dlygate4sd3_1
X_4375_ clknet_leaf_13_clk _0601_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_3326_ _1615_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3257_ _1579_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__clkbuf_1
X_2208_ net50 net469 _0910_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__mux2_1
X_3188_ _1542_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__clkbuf_1
X_2139_ _0875_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold681 instance_1.mem\[3\]\[19\] VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__dlygate4sd3_1
Xhold670 instance_1.mem\[3\]\[9\] VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__dlygate4sd3_1
Xhold692 instance_1.mem\[1\]\[42\] VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_27_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2490_ _0951_ _0952_ instance_0.mem\[3\]\[56\] VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__and3_1
XFILLER_0_10_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4160_ clknet_leaf_19_clk _0386_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_3111_ net639 net48 _1497_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__mux2_1
X_4091_ clknet_leaf_10_clk _0317_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_3042_ net42 net961 _1460_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3944_ clknet_leaf_7_clk net200 VGND VGND VPWR VPWR instance_0.rdata\[56\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3875_ clknet_leaf_10_clk _0101_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_2826_ net9 net615 _1346_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2757_ net313 _1295_ _1307_ _1308_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__o22a_1
X_2688_ net167 _1232_ _1259_ _1260_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__o22a_1
XFILLER_0_76_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4427_ clknet_leaf_26_clk _0653_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[35\] sky130_fd_sc_hd__dfxtp_1
X_4358_ clknet_leaf_28_clk _0584_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_4289_ clknet_leaf_16_clk _0515_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[41\] sky130_fd_sc_hd__dfxtp_1
X_3309_ _1606_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1990_ instance_0.rdata\[65\] instance_1.rdata\[65\] _0788_ VGND VGND VPWR VPWR _0794_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3660_ net45 net690 _1784_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__mux2_1
X_2611_ instance_1.mem\[1\]\[16\] _1111_ _1177_ instance_1.mem\[3\]\[16\] VGND VGND
+ VPWR VPWR _1206_ sky130_fd_sc_hd__a22o_1
X_3591_ net9 net524 _1751_ VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__mux2_1
X_2542_ _0962_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__buf_4
X_4212_ clknet_leaf_23_clk _0438_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_2473_ _1100_ _1101_ _1104_ _1089_ net149 VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__o32a_1
XTAP_TAPCELL_ROW_79_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4143_ clknet_leaf_24_clk _0369_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[39\] sky130_fd_sc_hd__dfxtp_1
X_4074_ clknet_leaf_17_clk _0300_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[42\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3025_ net33 net814 _1449_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_34_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3927_ clknet_leaf_25_clk _0153_ VGND VGND VPWR VPWR instance_0.rdata\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3858_ clknet_leaf_17_clk _0084_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[42\] sky130_fd_sc_hd__dfxtp_1
X_3789_ clknet_leaf_16_clk _0015_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[45\] sky130_fd_sc_hd__dfxtp_1
X_2809_ net70 net686 _1335_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1973_ instance_0.rdata\[57\] instance_1.rdata\[57\] _0777_ VGND VGND VPWR VPWR _0785_
+ sky130_fd_sc_hd__mux2_1
X_3712_ net415 net4 _0850_ VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3643_ net36 net578 _1773_ VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3574_ net70 net546 _1740_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2525_ instance_0.mem\[0\]\[66\] _1042_ _1108_ instance_0.mem\[3\]\[66\] VGND VGND
+ VPWR VPWR _1142_ sky130_fd_sc_hd__a22o_1
X_2456_ net221 _1056_ _1090_ _1091_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__o22a_1
Xhold29 instance_1.rdata\[34\] VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 _0129_ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4126_ clknet_leaf_37_clk _0352_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2387_ net249 _1024_ _1038_ _1041_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__o22a_1
X_4057_ clknet_leaf_39_clk _0283_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_3008_ net24 net866 _1438_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_82_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3290_ _1596_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__clkbuf_1
X_2310_ instance_0.mem\[1\]\[9\] _0939_ _0958_ instance_0.mem\[3\]\[9\] VGND VGND
+ VPWR VPWR _0984_ sky130_fd_sc_hd__a22o_1
X_2241_ net67 net930 _0921_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__mux2_1
X_2172_ net31 net626 _0888_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1956_ instance_0.rdata\[49\] instance_1.rdata\[49\] _0766_ VGND VGND VPWR VPWR _0776_
+ sky130_fd_sc_hd__mux2_1
X_1887_ instance_0.rdata\[16\] instance_1.rdata\[16\] _0733_ VGND VGND VPWR VPWR _0740_
+ sky130_fd_sc_hd__mux2_1
X_3626_ _1774_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__clkbuf_1
X_3557_ net630 net72 _1658_ VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__mux2_1
X_2508_ _0945_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__clkbuf_8
X_3488_ net490 net35 _1692_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__mux2_1
X_2439_ net378 _1078_ _0935_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__mux2_1
X_4109_ clknet_leaf_47_clk _0335_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_50_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2790_ net303 _1159_ _1329_ _1330_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__o22a_1
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4460_ clknet_leaf_5_clk _0686_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[68\] sky130_fd_sc_hd__dfxtp_1
Xhold307 instance_1.mem\[1\]\[47\] VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__dlygate4sd3_1
X_3411_ net708 net15 _1659_ VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__mux2_1
Xhold318 instance_0.mem\[2\]\[17\] VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__dlygate4sd3_1
X_4391_ clknet_leaf_5_clk _0617_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[71\] sky130_fd_sc_hd__dfxtp_1
Xhold329 instance_0.mem\[3\]\[54\] VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__dlygate4sd3_1
X_3342_ net487 net39 _1622_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3273_ _1587_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2224_ net58 net505 _0910_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2155_ net22 net649 _0877_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__mux2_1
X_2086_ _0846_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_64_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2988_ _1436_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_391 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1939_ _0767_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__buf_1
XFILLER_0_31_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3609_ _1765_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__clkbuf_1
Xhold830 instance_1.mem\[0\]\[59\] VGND VGND VPWR VPWR net978 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_17_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_26_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_35_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3960_ clknet_leaf_54_clk _0186_ VGND VGND VPWR VPWR instance_1.rdata\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2911_ _1395_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__clkbuf_1
X_3891_ clknet_leaf_53_clk net198 VGND VGND VPWR VPWR instance_0.rdata\[3\] sky130_fd_sc_hd__dfxtp_1
X_2842_ _1359_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__clkbuf_1
X_2773_ instance_1.mem\[0\]\[65\] instance_1.mem\[1\]\[65\] instance_1.mem\[2\]\[65\]
+ instance_1.mem\[3\]\[65\] _0944_ _1278_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__mux4_1
XFILLER_0_60_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold104 _0155_ VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold115 instance_0.rdata\[71\] VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_44_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold126 _0234_ VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__dlygate4sd3_1
Xhold148 _0228_ VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__dlygate4sd3_1
Xhold137 instance_0.rdata\[34\] VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__dlygate4sd3_1
Xhold159 instance_0.rdata\[9\] VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__dlygate4sd3_1
X_4443_ clknet_leaf_3_clk _0669_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[51\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4374_ clknet_leaf_10_clk _0600_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[54\] sky130_fd_sc_hd__dfxtp_1
X_3325_ net515 net30 _1611_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__mux2_1
X_3256_ net407 net4 _1578_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__mux2_1
X_2207_ _0911_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_69_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3187_ net734 net38 _1541_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__mux2_1
X_2138_ net13 net941 _0866_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__mux2_1
X_2069_ _0837_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_24_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_62_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold660 instance_1.mem\[0\]\[8\] VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__dlygate4sd3_1
Xhold671 instance_1.mem\[2\]\[55\] VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__dlygate4sd3_1
Xhold693 instance_1.mem\[3\]\[29\] VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__dlygate4sd3_1
Xhold682 instance_0.mem\[0\]\[31\] VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_71_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_80_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3110_ _1501_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__clkbuf_1
X_4090_ clknet_leaf_7_clk _0316_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3041_ _1464_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_65_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_66_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3943_ clknet_leaf_13_clk _0169_ VGND VGND VPWR VPWR instance_0.rdata\[55\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3874_ clknet_leaf_8_clk _0100_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2825_ _1350_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_5_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2756_ instance_1.mem\[0\]\[59\] _1252_ _1103_ instance_1.mem\[2\]\[59\] _1297_ VGND
+ VGND VPWR VPWR _1308_ sky130_fd_sc_hd__a221o_1
X_2687_ instance_1.mem\[1\]\[38\] _1244_ _1086_ instance_1.mem\[0\]\[38\] _1230_ VGND
+ VGND VPWR VPWR _1260_ sky130_fd_sc_hd__a221o_1
X_4426_ clknet_leaf_30_clk _0652_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4357_ clknet_leaf_22_clk _0583_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_3308_ net659 net21 _1600_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__mux2_1
X_4288_ clknet_leaf_20_clk _0514_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_3239_ net379 net65 _1563_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold490 instance_0.mem\[0\]\[57\] VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_27_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2610_ _1159_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__buf_4
X_3590_ _1755_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2541_ instance_0.mem\[3\]\[71\] _1016_ _1105_ instance_0.mem\[2\]\[71\] VGND VGND
+ VPWR VPWR _1153_ sky130_fd_sc_hd__a22o_1
X_2472_ instance_0.mem\[1\]\[51\] _1102_ _1103_ instance_0.mem\[2\]\[51\] VGND VGND
+ VPWR VPWR _1104_ sky130_fd_sc_hd__a22o_1
XFILLER_0_50_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4211_ clknet_leaf_26_clk _0437_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[35\] sky130_fd_sc_hd__dfxtp_1
X_4142_ clknet_leaf_26_clk _0368_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[38\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_79_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4073_ clknet_leaf_16_clk _0299_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[41\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3024_ _1455_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3926_ clknet_leaf_28_clk net156 VGND VGND VPWR VPWR instance_0.rdata\[38\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3857_ clknet_leaf_15_clk _0083_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3788_ clknet_leaf_18_clk _0014_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[44\] sky130_fd_sc_hd__dfxtp_1
X_2808_ _1341_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__clkbuf_1
X_2739_ instance_1.mem\[1\]\[54\] _1224_ _0991_ instance_1.mem\[3\]\[54\] VGND VGND
+ VPWR VPWR _1296_ sky130_fd_sc_hd__a22o_1
X_4409_ clknet_leaf_41_clk _0635_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_6_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_76_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1972_ _0784_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__buf_1
X_3711_ _1818_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__clkbuf_1
X_3642_ _1782_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3573_ _1746_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2524_ net185 _1089_ _1140_ _1141_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__o22a_1
X_2455_ instance_0.mem\[1\]\[47\] _1058_ _1071_ instance_0.mem\[3\]\[47\] _1074_ VGND
+ VGND VPWR VPWR _1091_ sky130_fd_sc_hd__a221o_1
Xhold19 instance_1.rdata\[38\] VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dlygate4sd3_1
X_2386_ instance_0.mem\[0\]\[28\] _1039_ _1040_ instance_0.mem\[2\]\[28\] _1036_ VGND
+ VGND VPWR VPWR _1041_ sky130_fd_sc_hd__a221o_1
X_4125_ clknet_leaf_39_clk _0351_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4056_ clknet_leaf_35_clk _0282_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[24\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3007_ _1446_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_82_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3909_ clknet_leaf_39_clk net174 VGND VGND VPWR VPWR instance_0.rdata\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2240_ _0928_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2171_ _0892_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1955_ _0775_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__buf_1
XFILLER_0_28_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1886_ _0739_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3625_ net27 net609 _1773_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__mux2_1
X_3556_ _1736_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__clkbuf_1
X_2507_ net253 _1092_ _1126_ _1129_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__o22a_1
XFILLER_0_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3487_ _1700_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__clkbuf_1
X_2438_ instance_0.mem\[0\]\[43\] instance_0.mem\[1\]\[43\] instance_0.mem\[2\]\[43\]
+ instance_0.mem\[3\]\[43\] _0973_ _0974_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__mux4_1
X_2369_ _0951_ _0952_ instance_0.mem\[3\]\[24\] VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__and3_1
X_4108_ clknet_leaf_51_clk _0334_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_4039_ clknet_leaf_46_clk _0265_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold308 instance_0.rdata\[6\] VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3410_ _1660_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4390_ clknet_leaf_6_clk _0616_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[70\] sky130_fd_sc_hd__dfxtp_1
Xhold319 instance_0.mem\[3\]\[48\] VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__dlygate4sd3_1
X_3341_ _1623_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__clkbuf_1
X_3272_ net729 net74 _1578_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__mux2_1
X_2223_ _0919_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__clkbuf_1
X_2154_ _0883_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__clkbuf_1
X_2085_ net655 net66 _0839_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_64_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2987_ net13 net486 _1427_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__mux2_1
X_1938_ instance_0.rdata\[40\] instance_1.rdata\[40\] _0766_ VGND VGND VPWR VPWR _0767_
+ sky130_fd_sc_hd__mux2_1
X_1869_ _0730_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold820 instance_0.mem\[2\]\[60\] VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_31_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3608_ net18 net910 _1762_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__mux2_1
Xhold831 instance_0.mem\[0\]\[24\] VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__dlygate4sd3_1
X_3539_ net471 net62 _1725_ VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_27_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2910_ net53 net607 _1390_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__mux2_1
X_3890_ clknet_leaf_51_clk net206 VGND VGND VPWR VPWR instance_0.rdata\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_61_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2841_ net17 net617 _1357_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__mux2_1
X_2772_ net275 _1295_ _1317_ _1318_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__o22a_1
XFILLER_0_41_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4442_ clknet_leaf_13_clk _0668_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[50\] sky130_fd_sc_hd__dfxtp_1
Xhold105 instance_0.rdata\[60\] VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__dlygate4sd3_1
Xhold116 _0185_ VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__dlygate4sd3_1
Xhold138 _0148_ VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__dlygate4sd3_1
Xhold149 instance_0.rdata\[1\] VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__dlygate4sd3_1
Xhold127 instance_1.rdata\[64\] VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__dlygate4sd3_1
X_4373_ clknet_leaf_7_clk _0599_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3324_ _1614_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__clkbuf_1
X_3255_ _1577_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__buf_4
X_2206_ net49 net719 _0910_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_69_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3186_ _1496_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__buf_4
XFILLER_0_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2137_ _0874_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2068_ net636 net57 _0828_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold650 instance_0.mem\[3\]\[26\] VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__dlygate4sd3_1
Xhold672 instance_0.mem\[0\]\[58\] VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__dlygate4sd3_1
Xhold661 instance_1.mem\[1\]\[30\] VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__dlygate4sd3_1
Xhold694 instance_1.mem\[2\]\[52\] VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__dlygate4sd3_1
Xhold683 instance_0.mem\[1\]\[22\] VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__dlygate4sd3_1
X_3040_ net41 net676 _1460_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3942_ clknet_leaf_9_clk net162 VGND VGND VPWR VPWR instance_0.rdata\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3873_ clknet_leaf_14_clk _0099_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_2824_ net8 net587 _1346_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2755_ instance_1.mem\[1\]\[59\] _1224_ _0991_ instance_1.mem\[3\]\[59\] VGND VGND
+ VPWR VPWR _1307_ sky130_fd_sc_hd__a22o_1
X_2686_ instance_1.mem\[3\]\[38\] _1184_ _1248_ instance_1.mem\[2\]\[38\] VGND VGND
+ VPWR VPWR _1259_ sky130_fd_sc_hd__a22o_1
X_4425_ clknet_leaf_30_clk _0651_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4356_ clknet_leaf_23_clk _0582_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_3307_ _1605_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__clkbuf_1
X_4287_ clknet_leaf_25_clk _0513_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[39\] sky130_fd_sc_hd__dfxtp_1
X_3238_ _1568_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__clkbuf_1
X_3169_ _1532_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_37_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold480 instance_1.mem\[2\]\[13\] VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_9_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold491 instance_1.mem\[3\]\[4\] VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2540_ net305 _1089_ _1151_ _1152_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__o22a_1
X_2471_ _0949_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__buf_4
X_4210_ clknet_leaf_29_clk _0436_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_79_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4141_ clknet_leaf_22_clk _0367_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_4072_ clknet_leaf_21_clk _0298_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[40\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3023_ net32 net551 _1449_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3925_ clknet_leaf_22_clk net202 VGND VGND VPWR VPWR instance_0.rdata\[37\] sky130_fd_sc_hd__dfxtp_1
X_3856_ clknet_leaf_21_clk _0082_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_3787_ clknet_leaf_25_clk _0013_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[43\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_81_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2807_ net59 net765 _1335_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2738_ _1159_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__buf_4
X_2669_ instance_1.mem\[1\]\[33\] _1244_ _1154_ instance_1.mem\[0\]\[33\] _1230_ VGND
+ VGND VPWR VPWR _1247_ sky130_fd_sc_hd__a221o_1
X_4408_ clknet_leaf_45_clk _0634_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4339_ clknet_leaf_38_clk _0565_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_57_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_57_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_48_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3710_ net72 net661 _1739_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__mux2_1
X_1971_ instance_0.rdata\[56\] instance_1.rdata\[56\] _0777_ VGND VGND VPWR VPWR _0784_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3641_ net35 net653 _1773_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3572_ net59 net614 _1740_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2523_ instance_0.mem\[0\]\[65\] _1039_ _1127_ instance_0.mem\[2\]\[65\] _1128_ VGND
+ VGND VPWR VPWR _1141_ sky130_fd_sc_hd__a221o_1
XFILLER_0_51_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2454_ instance_0.mem\[0\]\[47\] _1042_ _1008_ instance_0.mem\[2\]\[47\] VGND VGND
+ VPWR VPWR _1090_ sky130_fd_sc_hd__a22o_1
X_2385_ _0978_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__buf_4
X_4124_ clknet_leaf_35_clk _0350_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[20\] sky130_fd_sc_hd__dfxtp_1
Xinput1 address[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_2
Xclkbuf_leaf_48_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_48_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_36_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4055_ clknet_leaf_37_clk _0281_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_3006_ net23 net887 _1438_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_19_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3908_ clknet_leaf_35_clk net278 VGND VGND VPWR VPWR instance_0.rdata\[20\] sky130_fd_sc_hd__dfxtp_1
X_3839_ clknet_leaf_37_clk _0065_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[23\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_39_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_39_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_45_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2170_ net30 net622 _0888_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_16_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1954_ instance_0.rdata\[48\] instance_1.rdata\[48\] _0766_ VGND VGND VPWR VPWR _0775_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1885_ instance_0.rdata\[15\] instance_1.rdata\[15\] _0733_ VGND VGND VPWR VPWR _0739_
+ sky130_fd_sc_hd__mux2_1
X_3624_ _1739_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__buf_4
X_3555_ net815 net71 _1658_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2506_ instance_0.mem\[0\]\[60\] _1039_ _1127_ instance_0.mem\[2\]\[60\] _1128_ VGND
+ VGND VPWR VPWR _1129_ sky130_fd_sc_hd__a221o_1
X_3486_ net699 net34 _1692_ VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__mux2_1
X_2437_ net237 _1056_ _1076_ _1077_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__o22a_1
X_2368_ instance_0.mem\[2\]\[24\] _0986_ _0942_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__a21o_1
X_4107_ clknet_leaf_55_clk _0333_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_2299_ net456 _0975_ _0936_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__mux2_1
X_4038_ clknet_leaf_55_clk _0264_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_6_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold309 instance_0.rdata\[30\] VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3340_ net497 net38 _1622_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3271_ _1586_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__clkbuf_1
X_2222_ net57 net820 _0910_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__mux2_1
X_2153_ net21 net743 _0877_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__mux2_1
X_2084_ _0845_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2986_ _1435_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1937_ _0721_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__buf_4
X_1868_ instance_0.rdata\[7\] instance_1.rdata\[7\] _0722_ VGND VGND VPWR VPWR _0730_
+ sky130_fd_sc_hd__mux2_1
Xhold821 instance_0.mem\[0\]\[42\] VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__dlygate4sd3_1
Xinput70 wdata[6] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkbuf_2
X_3607_ _1764_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__clkbuf_1
Xhold810 instance_0.mem\[0\]\[22\] VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__dlygate4sd3_1
X_3538_ _1727_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__clkbuf_1
Xhold832 instance_0.mem\[2\]\[53\] VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__dlygate4sd3_1
X_3469_ net552 net25 _1681_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_55_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2840_ _1358_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2771_ instance_1.mem\[1\]\[64\] _1102_ _0957_ instance_1.mem\[3\]\[64\] _1297_ VGND
+ VGND VPWR VPWR _1318_ sky130_fd_sc_hd__a221o_1
XFILLER_0_5_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold106 _0174_ VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__dlygate4sd3_1
Xhold117 instance_0.rdata\[68\] VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__dlygate4sd3_1
X_4441_ clknet_leaf_18_clk _0667_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[49\] sky130_fd_sc_hd__dfxtp_1
Xhold139 instance_1.rdata\[30\] VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold128 _0250_ VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__dlygate4sd3_1
X_4372_ clknet_leaf_14_clk _0598_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[52\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3323_ net537 net29 _1611_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__mux2_1
X_3254_ _1576_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__buf_4
X_2205_ _0854_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_69_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3185_ _1540_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__clkbuf_1
X_2136_ net12 net745 _0866_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2067_ _0836_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2969_ _1426_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_32_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold651 instance_0.mem\[3\]\[41\] VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__dlygate4sd3_1
Xhold640 instance_1.mem\[0\]\[25\] VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__dlygate4sd3_1
Xhold662 instance_0.mem\[1\]\[31\] VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__dlygate4sd3_1
Xhold684 instance_0.mem\[0\]\[12\] VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__dlygate4sd3_1
Xhold673 instance_0.mem\[0\]\[27\] VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__dlygate4sd3_1
Xhold695 instance_0.mem\[1\]\[32\] VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_27_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3941_ clknet_leaf_11_clk net326 VGND VGND VPWR VPWR instance_0.rdata\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_85_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3872_ clknet_leaf_7_clk _0098_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_2823_ _1349_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_38_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2754_ net335 _1295_ _1305_ _1306_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__o22a_1
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2685_ net367 _1232_ _1256_ _1258_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__o22a_1
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4424_ clknet_leaf_31_clk _0650_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_4355_ clknet_leaf_26_clk _0581_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3306_ net571 net20 _1600_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__mux2_1
X_4286_ clknet_leaf_29_clk _0512_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_3237_ net861 net64 _1563_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__mux2_1
X_3168_ net392 net28 _1530_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__mux2_1
X_2119_ net75 net953 _0855_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3099_ _1494_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold470 instance_1.mem\[1\]\[44\] VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__dlygate4sd3_1
Xhold481 instance_0.mem\[1\]\[51\] VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_9_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold492 instance_0.mem\[1\]\[25\] VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_71_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2470_ _0803_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__buf_4
X_4140_ clknet_leaf_23_clk _0366_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[36\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_79_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4071_ clknet_leaf_24_clk _0297_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[39\] sky130_fd_sc_hd__dfxtp_1
X_3022_ _1454_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3924_ clknet_leaf_27_clk net190 VGND VGND VPWR VPWR instance_0.rdata\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3855_ clknet_leaf_24_clk _0081_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3786_ clknet_leaf_17_clk _0012_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[42\] sky130_fd_sc_hd__dfxtp_1
X_2806_ _1340_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__clkbuf_1
X_2737_ _1294_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2668_ instance_1.mem\[3\]\[33\] _1184_ _1197_ instance_1.mem\[2\]\[33\] VGND VGND
+ VPWR VPWR _1246_ sky130_fd_sc_hd__a22o_1
X_4407_ clknet_leaf_44_clk _0633_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_2599_ _0978_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_6_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4338_ clknet_leaf_41_clk _0564_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_4269_ clknet_leaf_40_clk _0495_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1970_ _0783_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3640_ _1781_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__clkbuf_1
X_3571_ _1745_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_11_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2522_ instance_0.mem\[1\]\[65\] _1111_ _1108_ instance_0.mem\[3\]\[65\] VGND VGND
+ VPWR VPWR _1140_ sky130_fd_sc_hd__a22o_1
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2453_ _1085_ _1087_ _1088_ _1089_ net151 VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__o32a_1
X_2384_ _0946_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__clkbuf_8
X_4123_ clknet_leaf_37_clk _0349_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_3_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4054_ clknet_leaf_39_clk _0280_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[22\] sky130_fd_sc_hd__dfxtp_1
Xinput2 address[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_2
X_3005_ _1445_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3907_ clknet_leaf_38_clk _0133_ VGND VGND VPWR VPWR instance_0.rdata\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3838_ clknet_leaf_37_clk _0064_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_61_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3769_ _1848_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1953_ _0774_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_1
X_1884_ _0738_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3623_ _1772_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__clkbuf_1
X_3554_ _1735_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__clkbuf_1
X_3485_ _1699_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__clkbuf_1
X_2505_ _0941_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__clkbuf_4
X_2436_ instance_0.mem\[1\]\[42\] _1058_ _1040_ instance_0.mem\[2\]\[42\] _1074_ VGND
+ VGND VPWR VPWR _1077_ sky130_fd_sc_hd__a221o_1
X_2367_ net235 _1024_ _1025_ _1026_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__o22a_1
X_2298_ instance_0.mem\[0\]\[6\] instance_0.mem\[1\]\[6\] instance_0.mem\[2\]\[6\]
+ instance_0.mem\[3\]\[6\] _0973_ _0974_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__mux4_1
X_4106_ clknet_leaf_51_clk _0332_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4037_ clknet_leaf_53_clk _0263_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3270_ net735 net73 _1578_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__mux2_1
X_2221_ _0918_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__clkbuf_1
X_2152_ _0882_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__clkbuf_1
X_2083_ net377 net65 _0839_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2985_ net12 net466 _1427_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__mux2_1
X_1936_ _0765_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1867_ _0729_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_1
Xhold800 instance_0.mem\[2\]\[42\] VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__dlygate4sd3_1
Xinput60 wdata[60] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_2
Xhold811 instance_1.mem\[0\]\[2\] VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__dlygate4sd3_1
X_3606_ net17 net970 _1762_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__mux2_1
Xinput71 wdata[70] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__buf_2
XFILLER_0_12_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold822 instance_1.mem\[0\]\[21\] VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__dlygate4sd3_1
X_3537_ net665 net61 _1725_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__mux2_1
Xhold833 instance_1.mem\[2\]\[59\] VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__dlygate4sd3_1
X_3468_ _1690_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__clkbuf_1
X_3399_ _1653_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__clkbuf_1
X_2419_ instance_0.mem\[0\]\[37\] _1039_ _1040_ instance_0.mem\[2\]\[37\] _1036_ VGND
+ VGND VPWR VPWR _1065_ sky130_fd_sc_hd__a221o_1
XFILLER_0_79_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_55_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2770_ instance_1.mem\[0\]\[64\] _0993_ _0950_ instance_1.mem\[2\]\[64\] VGND VGND
+ VPWR VPWR _1317_ sky130_fd_sc_hd__a22o_1
XFILLER_0_13_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold107 instance_1.rdata\[45\] VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4440_ clknet_leaf_21_clk _0666_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[48\] sky130_fd_sc_hd__dfxtp_1
Xhold118 _0182_ VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__dlygate4sd3_1
Xhold129 instance_0.rdata\[20\] VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__dlygate4sd3_1
X_4371_ clknet_leaf_9_clk _0597_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[51\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_13_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3322_ _1613_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__clkbuf_1
X_3253_ _0801_ _0949_ _0720_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__and3b_1
X_3184_ net570 net36 _1530_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__mux2_1
X_2204_ _0909_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_69_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2135_ _0873_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__clkbuf_1
X_2066_ net634 net56 _0828_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_22_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2968_ net75 net874 _1416_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_60_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1919_ instance_0.rdata\[31\] instance_1.rdata\[31\] _0755_ VGND VGND VPWR VPWR _0757_
+ sky130_fd_sc_hd__mux2_1
X_2899_ net47 net560 _1379_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__mux2_1
Xhold630 instance_0.mem\[3\]\[5\] VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold641 instance_0.mem\[1\]\[41\] VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold652 instance_1.mem\[2\]\[61\] VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__dlygate4sd3_1
Xhold663 instance_0.mem\[2\]\[25\] VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__dlygate4sd3_1
Xhold685 instance_1.mem\[1\]\[36\] VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__dlygate4sd3_1
Xhold674 instance_0.mem\[1\]\[3\] VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__dlygate4sd3_1
Xhold696 instance_0.mem\[0\]\[56\] VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_40_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3940_ clknet_leaf_15_clk net180 VGND VGND VPWR VPWR instance_0.rdata\[52\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_74_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3871_ clknet_leaf_13_clk _0097_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_2822_ net7 net644 _1346_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__mux2_1
X_2753_ instance_1.mem\[1\]\[58\] _1102_ _1086_ instance_1.mem\[0\]\[58\] _1297_ VGND
+ VGND VPWR VPWR _1306_ sky130_fd_sc_hd__a221o_1
XFILLER_0_26_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2684_ instance_1.mem\[0\]\[37\] _1252_ _1181_ instance_1.mem\[2\]\[37\] _1257_ VGND
+ VGND VPWR VPWR _1258_ sky130_fd_sc_hd__a221o_1
X_4423_ clknet_leaf_34_clk _0649_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4354_ clknet_leaf_28_clk _0580_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3305_ _1604_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__clkbuf_1
X_4285_ clknet_leaf_21_clk _0511_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_3236_ _1567_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__clkbuf_1
X_3167_ _1531_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__clkbuf_1
X_2118_ _0864_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
X_3098_ net72 net951 _1415_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2049_ net435 net47 _0817_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold460 instance_0.mem\[3\]\[67\] VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__dlygate4sd3_1
Xhold471 instance_1.rdata\[31\] VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_9_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold482 instance_0.mem\[3\]\[71\] VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__dlygate4sd3_1
Xhold493 instance_1.mem\[2\]\[64\] VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_71_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4070_ clknet_leaf_28_clk _0296_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_3021_ net31 net681 _1449_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3923_ clknet_leaf_26_clk net196 VGND VGND VPWR VPWR instance_0.rdata\[35\] sky130_fd_sc_hd__dfxtp_1
X_3854_ clknet_leaf_27_clk _0080_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[38\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2805_ net48 net675 _1335_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3785_ clknet_leaf_16_clk _0011_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2736_ net658 _1293_ _1188_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__mux2_1
X_2667_ net373 _1232_ _1243_ _1245_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__o22a_1
X_4406_ clknet_leaf_46_clk _0632_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2598_ net345 _1163_ _1195_ _1196_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_6_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4337_ clknet_leaf_42_clk _0563_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_4268_ clknet_leaf_36_clk _0494_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_3219_ _1558_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__clkbuf_1
X_4199_ clknet_leaf_50_clk _0425_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold290 instance_1.rdata\[18\] VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_84_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3570_ net48 net741 _1740_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_11_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2521_ net293 _1089_ _1138_ _1139_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__o22a_1
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2452_ _0936_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2383_ instance_0.mem\[1\]\[28\] _1021_ _1030_ instance_0.mem\[3\]\[28\] VGND VGND
+ VPWR VPWR _1038_ sky130_fd_sc_hd__a22o_1
X_4122_ clknet_leaf_38_clk _0348_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_3_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4053_ clknet_leaf_39_clk _0279_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[21\] sky130_fd_sc_hd__dfxtp_1
Xinput3 address[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__dlymetal6s2s_1
X_3004_ net22 net921 _1438_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_19_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3906_ clknet_leaf_41_clk net270 VGND VGND VPWR VPWR instance_0.rdata\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3837_ clknet_leaf_39_clk _0063_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3768_ net584 net23 _1838_ VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__mux2_1
X_2719_ _1282_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__clkbuf_1
X_3699_ _1812_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_81_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_69_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1952_ instance_0.rdata\[47\] instance_1.rdata\[47\] _0766_ VGND VGND VPWR VPWR _0774_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1883_ instance_0.rdata\[14\] instance_1.rdata\[14\] _0733_ VGND VGND VPWR VPWR _0738_
+ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_78_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3622_ net25 net853 _1762_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3553_ net575 net69 _1725_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__mux2_1
X_3484_ net862 net33 _1692_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__mux2_1
X_2504_ _0949_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__buf_4
X_2435_ instance_0.mem\[0\]\[42\] _1042_ _1030_ instance_0.mem\[3\]\[42\] VGND VGND
+ VPWR VPWR _1076_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_87_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4105_ clknet_leaf_53_clk _0331_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_2366_ instance_0.mem\[1\]\[23\] _1010_ _0979_ instance_0.mem\[2\]\[23\] _0999_ VGND
+ VGND VPWR VPWR _1026_ sky130_fd_sc_hd__a221o_1
XFILLER_0_47_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2297_ _0945_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4036_ clknet_leaf_51_clk _0262_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_502 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2220_ net56 net638 _0910_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2151_ net20 net979 _0877_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__mux2_1
X_2082_ _0844_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2984_ _1434_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__clkbuf_1
X_1935_ instance_0.rdata\[39\] instance_1.rdata\[39\] _0755_ VGND VGND VPWR VPWR _0765_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1866_ instance_0.rdata\[6\] instance_1.rdata\[6\] _0722_ VGND VGND VPWR VPWR _0729_
+ sky130_fd_sc_hd__mux2_1
Xhold801 instance_1.mem\[0\]\[35\] VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput61 wdata[61] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_2
Xinput72 wdata[71] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__buf_2
X_3605_ _1763_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__clkbuf_1
Xinput50 wdata[51] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_2
Xhold812 instance_0.mem\[0\]\[48\] VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__dlygate4sd3_1
X_3536_ _1726_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__clkbuf_1
Xhold823 instance_1.mem\[0\]\[24\] VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__dlygate4sd3_1
X_3467_ net688 net24 _1681_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__mux2_1
X_3398_ net737 net68 _1644_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__mux2_1
X_2418_ instance_0.mem\[1\]\[37\] _1021_ _1030_ instance_0.mem\[3\]\[37\] VGND VGND
+ VPWR VPWR _1064_ sky130_fd_sc_hd__a22o_1
X_2349_ net269 _0990_ _1012_ _1013_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_55_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4019_ clknet_leaf_11_clk net314 VGND VGND VPWR VPWR instance_1.rdata\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold108 _0231_ VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__dlygate4sd3_1
X_4370_ clknet_leaf_13_clk _0596_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[50\] sky130_fd_sc_hd__dfxtp_1
Xhold119 instance_1.rdata\[16\] VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__dlygate4sd3_1
X_3321_ net399 net28 _1611_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3252_ _1575_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__clkbuf_1
X_3183_ _1539_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__clkbuf_1
X_2203_ net47 net606 _0899_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__mux2_1
X_2134_ net11 net873 _0866_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__mux2_1
X_2065_ _0835_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_24_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2967_ _1425_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_60_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1918_ _0756_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2898_ _1388_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__clkbuf_1
Xhold620 instance_1.mem\[2\]\[22\] VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold631 instance_1.mem\[1\]\[8\] VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__dlygate4sd3_1
Xhold653 instance_1.mem\[3\]\[61\] VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__dlygate4sd3_1
Xhold642 instance_1.mem\[2\]\[9\] VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3519_ _1717_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold675 instance_0.mem\[2\]\[62\] VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__dlygate4sd3_1
Xhold664 instance_1.mem\[3\]\[68\] VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__dlygate4sd3_1
Xhold686 instance_0.mem\[0\]\[20\] VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__dlygate4sd3_1
Xhold697 instance_1.mem\[0\]\[53\] VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_67_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_20_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_89_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3870_ clknet_leaf_10_clk _0096_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[54\] sky130_fd_sc_hd__dfxtp_1
X_2821_ _1348_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2752_ instance_1.mem\[3\]\[58\] _0988_ _0950_ instance_1.mem\[2\]\[58\] VGND VGND
+ VPWR VPWR _1305_ sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_11_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_11_clk sky130_fd_sc_hd__clkbuf_8
X_2683_ _0973_ _0945_ instance_1.mem\[3\]\[37\] VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__and3_1
X_4422_ clknet_leaf_22_clk _0648_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_4353_ clknet_leaf_30_clk _0579_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[33\] sky130_fd_sc_hd__dfxtp_1
X_4284_ clknet_leaf_27_clk _0510_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_3304_ net472 net19 _1600_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__mux2_1
X_3235_ net419 net63 _1563_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__mux2_1
X_3166_ net667 net27 _1530_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__mux2_1
X_2117_ net74 net733 _0855_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__mux2_1
X_3097_ _1493_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2048_ _0826_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3999_ clknet_leaf_25_clk net172 VGND VGND VPWR VPWR instance_1.rdata\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold450 instance_0.mem\[0\]\[38\] VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__dlygate4sd3_1
Xhold472 instance_0.mem\[3\]\[17\] VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__dlygate4sd3_1
Xhold461 instance_1.mem\[0\]\[30\] VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__dlygate4sd3_1
Xhold494 instance_1.mem\[3\]\[43\] VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__dlygate4sd3_1
Xhold483 instance_0.mem\[0\]\[35\] VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_0_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3020_ _1453_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_0_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_34_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3922_ clknet_leaf_30_clk net286 VGND VGND VPWR VPWR instance_0.rdata\[34\] sky130_fd_sc_hd__dfxtp_1
X_3853_ clknet_leaf_22_clk _0079_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_2804_ _1339_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3784_ clknet_leaf_20_clk _0010_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_2735_ instance_1.mem\[0\]\[53\] instance_1.mem\[1\]\[53\] instance_1.mem\[2\]\[53\]
+ instance_1.mem\[3\]\[53\] _1202_ _1278_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__mux4_1
X_2666_ instance_1.mem\[1\]\[32\] _1244_ _1071_ instance_1.mem\[3\]\[32\] _1230_ VGND
+ VGND VPWR VPWR _1245_ sky130_fd_sc_hd__a221o_1
X_4405_ clknet_leaf_43_clk _0631_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_4336_ clknet_leaf_45_clk _0562_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_2597_ instance_1.mem\[1\]\[12\] _1192_ _1181_ instance_1.mem\[2\]\[12\] _1193_ VGND
+ VGND VPWR VPWR _1196_ sky130_fd_sc_hd__a221o_1
X_4267_ clknet_leaf_40_clk _0493_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_4198_ clknet_leaf_37_clk _0424_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_3218_ net674 net54 _1552_ VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__mux2_1
X_3149_ net596 net18 _1519_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold280 instance_1.mem\[1\]\[46\] VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold291 instance_1.mem\[3\]\[10\] VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_76_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2520_ instance_0.mem\[1\]\[64\] _1122_ _1127_ instance_0.mem\[2\]\[64\] _1128_ VGND
+ VGND VPWR VPWR _1139_ sky130_fd_sc_hd__a221o_1
X_2451_ instance_0.mem\[3\]\[46\] _0988_ _0942_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__a21o_1
X_2382_ net347 _1024_ _1035_ _1037_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__o22a_1
X_4121_ clknet_leaf_42_clk _0347_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4052_ clknet_leaf_35_clk _0278_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[20\] sky130_fd_sc_hd__dfxtp_1
Xinput4 wdata[0] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_2
X_3003_ _1444_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3905_ clknet_leaf_41_clk net182 VGND VGND VPWR VPWR instance_0.rdata\[17\] sky130_fd_sc_hd__dfxtp_1
X_3836_ clknet_leaf_37_clk _0062_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_3767_ _1847_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__clkbuf_1
X_2718_ net567 _1281_ _1188_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__mux2_1
X_3698_ net65 net462 _1806_ VGND VGND VPWR VPWR _1812_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2649_ instance_1.mem\[0\]\[27\] _1190_ _1197_ instance_1.mem\[2\]\[27\] VGND VGND
+ VPWR VPWR _1233_ sky130_fd_sc_hd__a22o_1
X_4319_ clknet_leaf_5_clk _0545_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_81_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1951_ _0773_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__buf_1
XFILLER_0_71_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1882_ _0737_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3621_ _1771_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__clkbuf_1
X_3552_ _1734_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__clkbuf_1
X_2503_ instance_0.mem\[1\]\[60\] _1111_ _1108_ instance_0.mem\[3\]\[60\] VGND VGND
+ VPWR VPWR _1126_ sky130_fd_sc_hd__a22o_1
X_3483_ _1698_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__clkbuf_1
X_2434_ net251 _1056_ _1073_ _1075_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__o22a_1
X_2365_ instance_0.mem\[0\]\[23\] _0963_ _0958_ instance_0.mem\[3\]\[23\] VGND VGND
+ VPWR VPWR _1025_ sky130_fd_sc_hd__a22o_1
X_4104_ clknet_leaf_54_clk _0330_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2296_ _0944_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__buf_4
X_4035_ clknet_leaf_55_clk _0261_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_50_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3819_ clknet_leaf_53_clk _0045_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2150_ _0881_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2081_ net549 net64 _0839_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2983_ net11 net863 _1427_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__mux2_1
X_1934_ _0764_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput40 wdata[42] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_2
X_1865_ _0728_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__clkbuf_1
Xinput51 wdata[52] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_2
Xinput73 wdata[7] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__clkbuf_2
Xinput62 wdata[62] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_2
Xhold802 instance_0.mem\[2\]\[20\] VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__dlygate4sd3_1
X_3604_ net16 net877 _1762_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__mux2_1
Xhold813 instance_0.mem\[2\]\[44\] VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3535_ net580 net60 _1725_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__mux2_1
Xhold824 instance_0.mem\[2\]\[70\] VGND VGND VPWR VPWR net972 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3466_ _1689_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__clkbuf_1
X_2417_ net189 _1056_ _1062_ _1063_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__o22a_1
X_3397_ _1652_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__clkbuf_1
X_2348_ instance_0.mem\[1\]\[18\] _1010_ _0993_ instance_0.mem\[0\]\[18\] _0999_ VGND
+ VGND VPWR VPWR _1013_ sky130_fd_sc_hd__a221o_1
X_2279_ instance_0.mem\[0\]\[1\] _0947_ _0950_ instance_0.mem\[2\]\[1\] _0960_ VGND
+ VGND VPWR VPWR _0961_ sky130_fd_sc_hd__a221o_1
XFILLER_0_79_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4018_ clknet_leaf_6_clk net336 VGND VGND VPWR VPWR instance_1.rdata\[58\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold109 instance_1.rdata\[66\] VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3320_ _1612_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3251_ net448 net72 _1496_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__mux2_1
X_3182_ net460 net35 _1530_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__mux2_1
X_2202_ _0908_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__clkbuf_1
X_2133_ _0872_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__clkbuf_1
X_2064_ net518 net55 _0828_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2966_ net74 net973 _1416_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1917_ instance_0.rdata\[30\] instance_1.rdata\[30\] _0755_ VGND VGND VPWR VPWR _0756_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2897_ net46 net827 _1379_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold610 instance_1.mem\[0\]\[3\] VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__dlygate4sd3_1
Xhold621 instance_1.mem\[3\]\[25\] VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__dlygate4sd3_1
Xhold632 instance_1.mem\[0\]\[50\] VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold643 instance_0.mem\[3\]\[66\] VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__dlygate4sd3_1
Xhold654 instance_0.mem\[0\]\[53\] VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3518_ net443 net51 _1714_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__mux2_1
Xhold676 instance_0.mem\[2\]\[15\] VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold687 instance_0.mem\[3\]\[9\] VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__dlygate4sd3_1
Xhold665 instance_1.mem\[3\]\[33\] VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__dlygate4sd3_1
X_3449_ _1680_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__clkbuf_1
Xhold698 instance_0.mem\[3\]\[53\] VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_85_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2820_ net6 net870 _1346_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2751_ net289 _1295_ _1303_ _1304_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__o22a_1
XFILLER_0_14_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2682_ instance_1.mem\[1\]\[37\] _0939_ _1166_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__a21o_1
X_4421_ clknet_leaf_32_clk _0647_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4352_ clknet_leaf_34_clk _0578_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_4283_ clknet_leaf_26_clk _0509_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[35\] sky130_fd_sc_hd__dfxtp_1
X_3303_ _1603_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__clkbuf_1
X_3234_ _1566_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__clkbuf_1
X_3165_ _1496_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__buf_4
X_2116_ _0863_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
X_3096_ net71 net972 _1415_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_65_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2047_ net767 net46 _0817_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3998_ clknet_leaf_29_clk net168 VGND VGND VPWR VPWR instance_1.rdata\[38\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2949_ _1415_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__buf_4
XFILLER_0_44_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold462 instance_1.mem\[0\]\[45\] VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__dlygate4sd3_1
Xhold451 instance_1.mem\[3\]\[27\] VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__dlygate4sd3_1
Xhold440 instance_0.mem\[3\]\[57\] VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__dlygate4sd3_1
Xhold473 instance_1.mem\[3\]\[3\] VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__dlygate4sd3_1
Xhold495 instance_0.mem\[2\]\[54\] VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__dlygate4sd3_1
Xhold484 instance_0.mem\[2\]\[57\] VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_0_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3921_ clknet_leaf_30_clk net220 VGND VGND VPWR VPWR instance_0.rdata\[33\] sky130_fd_sc_hd__dfxtp_1
X_3852_ clknet_leaf_27_clk _0078_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_2803_ net37 net822 _1335_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3783_ clknet_leaf_25_clk _0009_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_26_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2734_ net239 _1261_ _1291_ _1292_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__o22a_1
X_2665_ _0803_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__buf_4
X_2596_ instance_1.mem\[0\]\[12\] _1190_ _1177_ instance_1.mem\[3\]\[12\] VGND VGND
+ VPWR VPWR _1195_ sky130_fd_sc_hd__a22o_1
X_4404_ clknet_leaf_49_clk _0630_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_4335_ clknet_leaf_44_clk _0561_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4266_ clknet_leaf_38_clk _0492_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_4197_ clknet_leaf_40_clk _0423_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_3217_ _1557_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__clkbuf_1
X_3148_ _1521_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3079_ _1484_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold270 instance_1.mem\[2\]\[10\] VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__dlygate4sd3_1
Xhold292 instance_1.mem\[3\]\[14\] VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__dlygate4sd3_1
Xhold281 instance_1.mem\[3\]\[18\] VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_76_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2450_ instance_0.mem\[1\]\[46\] _0938_ _1086_ instance_0.mem\[0\]\[46\] VGND VGND
+ VPWR VPWR _1087_ sky130_fd_sc_hd__a22o_1
X_2381_ instance_0.mem\[1\]\[27\] _1010_ _0993_ instance_0.mem\[0\]\[27\] _1036_ VGND
+ VGND VPWR VPWR _1037_ sky130_fd_sc_hd__a221o_1
X_4120_ clknet_leaf_45_clk _0346_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_4051_ clknet_leaf_38_clk _0277_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[19\] sky130_fd_sc_hd__dfxtp_1
Xinput5 wdata[10] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3002_ net21 net811 _1438_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_47_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3904_ clknet_leaf_45_clk net332 VGND VGND VPWR VPWR instance_0.rdata\[16\] sky130_fd_sc_hd__dfxtp_1
X_3835_ clknet_leaf_38_clk _0061_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_3766_ net717 net22 _1838_ VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2717_ instance_1.mem\[0\]\[47\] instance_1.mem\[1\]\[47\] instance_1.mem\[2\]\[47\]
+ instance_1.mem\[3\]\[47\] _1202_ _1278_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__mux4_1
XFILLER_0_72_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3697_ _1811_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__clkbuf_1
X_2648_ _1159_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__buf_4
X_2579_ _0973_ _0945_ instance_1.mem\[3\]\[8\] VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__and3_1
X_4318_ clknet_leaf_20_clk _0544_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[70\] sky130_fd_sc_hd__dfxtp_1
X_4249_ clknet_leaf_54_clk _0475_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_53_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1950_ instance_0.rdata\[46\] instance_1.rdata\[46\] _0766_ VGND VGND VPWR VPWR _0773_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1881_ instance_0.rdata\[13\] instance_1.rdata\[13\] _0733_ VGND VGND VPWR VPWR _0737_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3620_ net24 net755 _1762_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3551_ net919 net68 _1725_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__mux2_1
X_2502_ _1125_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
X_3482_ net423 net32 _1692_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__mux2_1
X_2433_ instance_0.mem\[0\]\[41\] _1039_ _1040_ instance_0.mem\[2\]\[41\] _1074_ VGND
+ VGND VPWR VPWR _1075_ sky130_fd_sc_hd__a221o_1
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2364_ _0936_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__buf_4
X_4103_ clknet_leaf_5_clk _0329_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[71\] sky130_fd_sc_hd__dfxtp_1
X_2295_ net327 _0937_ _0971_ _0972_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__o22a_1
X_4034_ clknet_leaf_51_clk _0260_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_10 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3818_ clknet_leaf_51_clk _0044_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_50_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3749_ _0805_ VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__buf_4
XFILLER_0_42_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_58_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2080_ _0843_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_29_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2982_ _1433_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__clkbuf_1
X_1933_ instance_0.rdata\[38\] instance_1.rdata\[38\] _0755_ VGND VGND VPWR VPWR _0764_
+ sky130_fd_sc_hd__mux2_1
Xinput30 wdata[33] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1864_ instance_0.rdata\[5\] instance_1.rdata\[5\] _0722_ VGND VGND VPWR VPWR _0728_
+ sky130_fd_sc_hd__mux2_1
X_3603_ _1739_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__buf_4
Xinput41 wdata[43] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_2
Xinput63 wdata[63] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_2
Xhold803 instance_0.mem\[2\]\[71\] VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__dlygate4sd3_1
Xinput52 wdata[53] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_2
Xhold814 instance_0.mem\[2\]\[5\] VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__dlygate4sd3_1
Xinput74 wdata[8] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__buf_2
Xhold825 instance_0.mem\[2\]\[8\] VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__dlygate4sd3_1
X_3534_ _1658_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__buf_4
XFILLER_0_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3465_ net669 net23 _1681_ VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__mux2_1
X_2416_ instance_0.mem\[1\]\[36\] _1058_ _1048_ instance_0.mem\[0\]\[36\] _1036_ VGND
+ VGND VPWR VPWR _1063_ sky130_fd_sc_hd__a221o_1
X_3396_ net391 net67 _1644_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__mux2_1
X_2347_ instance_0.mem\[3\]\[18\] _0991_ _1008_ instance_0.mem\[2\]\[18\] VGND VGND
+ VPWR VPWR _1012_ sky130_fd_sc_hd__a22o_1
XFILLER_0_74_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2278_ _0941_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__buf_4
XFILLER_0_74_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4017_ clknet_leaf_7_clk net290 VGND VGND VPWR VPWR instance_1.rdata\[57\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3250_ _1574_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__clkbuf_1
X_3181_ _1538_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__clkbuf_1
X_2201_ net46 net960 _0899_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__mux2_1
X_2132_ net10 net772 _0866_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__mux2_1
X_2063_ _0834_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2965_ _1424_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1916_ _0721_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__buf_4
XFILLER_0_60_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2896_ _1387_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__clkbuf_1
Xhold611 instance_0.mem\[1\]\[10\] VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__dlygate4sd3_1
Xhold600 instance_0.mem\[0\]\[7\] VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold633 instance_1.mem\[2\]\[3\] VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__dlygate4sd3_1
Xhold622 instance_1.mem\[0\]\[64\] VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__dlygate4sd3_1
Xhold644 instance_1.mem\[2\]\[70\] VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__dlygate4sd3_1
X_3517_ _1716_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__clkbuf_1
Xhold666 instance_0.mem\[2\]\[36\] VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__dlygate4sd3_1
Xhold655 instance_1.mem\[3\]\[48\] VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__dlygate4sd3_1
Xhold677 instance_0.mem\[2\]\[67\] VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__dlygate4sd3_1
Xhold688 instance_1.mem\[0\]\[68\] VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__dlygate4sd3_1
X_3448_ net383 net14 _1670_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__mux2_1
Xhold699 instance_0.mem\[1\]\[53\] VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__dlygate4sd3_1
X_3379_ net981 net58 _1633_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_89_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2750_ instance_1.mem\[1\]\[57\] _1102_ _1086_ instance_1.mem\[0\]\[57\] _1297_ VGND
+ VGND VPWR VPWR _1304_ sky130_fd_sc_hd__a221o_1
X_2681_ net227 _1232_ _1254_ _1255_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__o22a_1
XFILLER_0_14_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4420_ clknet_leaf_33_clk _0646_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_53_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4351_ clknet_leaf_22_clk _0577_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4282_ clknet_leaf_29_clk _0508_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[34\] sky130_fd_sc_hd__dfxtp_1
X_3302_ net768 net18 _1600_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__mux2_1
X_3233_ net513 net62 _1563_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__mux2_1
X_3164_ _1529_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__clkbuf_1
X_3095_ _1492_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__clkbuf_1
X_2115_ net73 net748 _0855_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_65_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2046_ _0825_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3997_ clknet_leaf_35_clk net368 VGND VGND VPWR VPWR instance_1.rdata\[37\] sky130_fd_sc_hd__dfxtp_1
X_2948_ _1414_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__buf_4
XFILLER_0_44_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2879_ _1378_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__clkbuf_1
Xhold430 instance_1.mem\[0\]\[39\] VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__dlygate4sd3_1
Xhold441 instance_0.mem\[2\]\[45\] VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__dlygate4sd3_1
Xhold452 instance_1.mem\[2\]\[36\] VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__dlygate4sd3_1
Xhold463 instance_1.mem\[2\]\[71\] VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__dlygate4sd3_1
Xhold485 instance_1.mem\[0\]\[34\] VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__dlygate4sd3_1
Xhold474 instance_0.mem\[0\]\[33\] VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__dlygate4sd3_1
Xhold496 instance_0.mem\[1\]\[12\] VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_67_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3920_ clknet_leaf_31_clk net184 VGND VGND VPWR VPWR instance_0.rdata\[32\] sky130_fd_sc_hd__dfxtp_1
X_3851_ clknet_leaf_27_clk _0077_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3782_ clknet_leaf_26_clk _0008_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_2802_ _1338_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__clkbuf_1
X_2733_ instance_1.mem\[0\]\[52\] _1252_ _1103_ instance_1.mem\[2\]\[52\] _1263_ VGND
+ VGND VPWR VPWR _1292_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_42_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2664_ instance_1.mem\[0\]\[32\] _1190_ _1197_ instance_1.mem\[2\]\[32\] VGND VGND
+ VPWR VPWR _1243_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2595_ net349 _1163_ _1191_ _1194_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__o22a_1
X_4403_ clknet_leaf_49_clk _0629_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_4334_ clknet_leaf_45_clk _0560_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_4265_ clknet_leaf_40_clk _0491_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3216_ net926 net53 _1552_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__mux2_1
X_4196_ clknet_leaf_36_clk _0422_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_3147_ net603 net17 _1519_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3078_ net61 net679 _1482_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2029_ _0816_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold271 instance_1.mem\[3\]\[63\] VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__dlygate4sd3_1
Xhold260 instance_1.mem\[3\]\[46\] VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__dlygate4sd3_1
Xhold293 instance_1.mem\[2\]\[4\] VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__dlygate4sd3_1
Xhold282 instance_1.mem\[3\]\[37\] VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_76_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2380_ _0941_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__clkbuf_4
X_4050_ clknet_leaf_41_clk _0276_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xinput6 wdata[11] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_2
X_3001_ _1443_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3903_ clknet_leaf_44_clk net166 VGND VGND VPWR VPWR instance_0.rdata\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3834_ clknet_leaf_41_clk _0060_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3765_ _1846_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__clkbuf_1
X_3696_ net64 net770 _1806_ VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__mux2_1
X_2716_ _1280_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__clkbuf_1
X_2647_ net365 _1205_ _1229_ _1231_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__o22a_1
X_2578_ _0949_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4317_ clknet_leaf_57_clk _0543_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_4248_ clknet_leaf_54_clk _0474_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4179_ clknet_leaf_52_clk _0405_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_81_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_29_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1880_ _0736_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__buf_1
XFILLER_0_22_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3550_ _1733_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2501_ net417 _1124_ _0935_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__mux2_1
X_3481_ _1697_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_47_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2432_ _0941_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__clkbuf_4
X_2363_ net169 _0990_ _1022_ _1023_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__o22a_1
X_4102_ clknet_leaf_6_clk _0328_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[70\] sky130_fd_sc_hd__dfxtp_1
X_2294_ instance_0.mem\[0\]\[5\] _0947_ _0950_ instance_0.mem\[2\]\[5\] _0960_ VGND
+ VGND VPWR VPWR _0972_ sky130_fd_sc_hd__a221o_1
X_4033_ clknet_leaf_47_clk _0259_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_56_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3817_ clknet_leaf_47_clk _0043_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3748_ _1837_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_65_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3679_ net55 net720 _1795_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__mux2_1
Xoutput140 net140 VGND VGND VPWR VPWR rdata[67] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_74_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_50_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_50_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_80_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_83_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2981_ net10 net824 _1427_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_41_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_41_clk sky130_fd_sc_hd__clkbuf_8
X_1932_ _0763_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_1
X_1863_ _0727_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_1
Xinput31 wdata[34] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_71_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3602_ _1761_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__clkbuf_1
Xinput20 wdata[24] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_2
Xinput42 wdata[44] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_2
Xinput64 wdata[64] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_2
Xinput53 wdata[54] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_2
Xhold804 instance_1.mem\[0\]\[36\] VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__dlygate4sd3_1
Xhold815 instance_0.mem\[1\]\[16\] VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__dlygate4sd3_1
Xinput75 wdata[9] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__buf_2
Xhold826 instance_1.mem\[0\]\[27\] VGND VGND VPWR VPWR net974 sky130_fd_sc_hd__dlygate4sd3_1
X_3533_ _1724_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__clkbuf_1
X_3464_ _1688_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__clkbuf_1
X_2415_ instance_0.mem\[3\]\[36\] _1016_ _1008_ instance_0.mem\[2\]\[36\] VGND VGND
+ VPWR VPWR _1062_ sky130_fd_sc_hd__a22o_1
XFILLER_0_58_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3395_ _1651_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__clkbuf_1
X_2346_ net181 _0990_ _1009_ _1011_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__o22a_1
X_2277_ instance_0.mem\[1\]\[1\] _0939_ _0958_ instance_0.mem\[3\]\[1\] VGND VGND
+ VPWR VPWR _0959_ sky130_fd_sc_hd__a22o_1
XFILLER_0_74_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4016_ clknet_leaf_7_clk net318 VGND VGND VPWR VPWR instance_1.rdata\[56\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_32_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_32_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_63_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_23_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_23_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_0_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2200_ _0907_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3180_ net430 net34 _1530_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__mux2_1
X_2131_ _0871_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__clkbuf_1
X_2062_ net739 net54 _0828_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__mux2_1
X_2964_ net73 net704 _1416_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_14_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_8
X_1915_ _0754_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_60_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2895_ net45 net907 _1379_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold612 instance_0.mem\[3\]\[11\] VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__dlygate4sd3_1
Xhold601 instance_1.mem\[1\]\[70\] VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold645 instance_0.mem\[0\]\[66\] VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__dlygate4sd3_1
Xhold623 instance_1.mem\[0\]\[19\] VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__dlygate4sd3_1
Xhold634 instance_1.mem\[3\]\[28\] VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__dlygate4sd3_1
X_3516_ net700 net50 _1714_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold678 instance_0.mem\[1\]\[15\] VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold656 instance_1.mem\[2\]\[2\] VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__dlygate4sd3_1
Xhold667 instance_0.mem\[3\]\[70\] VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__dlygate4sd3_1
X_3447_ _1679_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__clkbuf_1
Xhold689 instance_0.mem\[1\]\[46\] VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__dlygate4sd3_1
X_3378_ _1642_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__clkbuf_1
X_2329_ _0941_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_68_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_89_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2680_ instance_1.mem\[0\]\[36\] _1252_ _1181_ instance_1.mem\[2\]\[36\] _1230_ VGND
+ VGND VPWR VPWR _1255_ sky130_fd_sc_hd__a221o_1
XFILLER_0_81_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4350_ clknet_leaf_23_clk _0576_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_3301_ _1602_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4281_ clknet_leaf_30_clk _0507_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[33\] sky130_fd_sc_hd__dfxtp_1
X_3232_ _1565_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_3_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_8
X_3163_ net841 net25 _1519_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__mux2_1
X_2114_ _0862_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
X_3094_ net69 net685 _1482_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_65_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2045_ net455 net45 _0817_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3996_ clknet_leaf_27_clk net228 VGND VGND VPWR VPWR instance_1.rdata\[36\] sky130_fd_sc_hd__dfxtp_1
X_2947_ _0720_ _0801_ _0949_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__or3b_1
XFILLER_0_72_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2878_ net36 net646 _1368_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_496 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold420 instance_1.mem\[2\]\[45\] VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__dlygate4sd3_1
Xhold442 instance_1.mem\[3\]\[35\] VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__dlygate4sd3_1
Xhold431 instance_1.mem\[1\]\[2\] VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__dlygate4sd3_1
Xhold453 instance_0.mem\[3\]\[22\] VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__dlygate4sd3_1
Xhold475 instance_0.mem\[0\]\[45\] VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__dlygate4sd3_1
X_4479_ clknet_leaf_44_clk _0705_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold464 instance_1.mem\[2\]\[54\] VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__dlygate4sd3_1
Xhold486 instance_1.mem\[1\]\[57\] VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__dlygate4sd3_1
Xhold497 instance_1.mem\[0\]\[18\] VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3850_ clknet_leaf_28_clk _0076_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2801_ net26 net805 _1335_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__mux2_1
X_3781_ clknet_leaf_35_clk _0007_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_2732_ instance_1.mem\[1\]\[52\] _1224_ _0991_ instance_1.mem\[3\]\[52\] VGND VGND
+ VPWR VPWR _1291_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_42_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2663_ _1242_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__clkbuf_1
X_4402_ clknet_leaf_46_clk _0628_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_2594_ instance_1.mem\[1\]\[11\] _1192_ _1071_ instance_1.mem\[3\]\[11\] _1193_ VGND
+ VGND VPWR VPWR _1194_ sky130_fd_sc_hd__a221o_1
X_4333_ clknet_leaf_42_clk _0559_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4264_ clknet_leaf_48_clk _0490_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3215_ _1556_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__clkbuf_1
X_4195_ clknet_leaf_40_clk _0421_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_3146_ _1520_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__clkbuf_1
X_3077_ _1483_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2028_ net437 net36 _0806_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3979_ clknet_leaf_40_clk net372 VGND VGND VPWR VPWR instance_1.rdata\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold261 instance_1.mem\[1\]\[28\] VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__dlygate4sd3_1
Xhold250 instance_0.mem\[3\]\[56\] VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__dlygate4sd3_1
Xhold294 instance_0.mem\[0\]\[43\] VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__dlygate4sd3_1
Xhold283 instance_0.mem\[3\]\[0\] VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__dlygate4sd3_1
Xhold272 instance_1.mem\[3\]\[57\] VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput7 wdata[12] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_2
X_3000_ net20 net852 _1438_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_47_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3902_ clknet_leaf_44_clk _0128_ VGND VGND VPWR VPWR instance_0.rdata\[14\] sky130_fd_sc_hd__dfxtp_1
X_3833_ clknet_leaf_43_clk _0059_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3764_ net713 net21 _1838_ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__mux2_1
X_3695_ _1810_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__clkbuf_1
X_2715_ net397 _1279_ _1188_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__mux2_1
X_2646_ instance_1.mem\[1\]\[26\] _1192_ _1154_ instance_1.mem\[0\]\[26\] _1230_ VGND
+ VGND VPWR VPWR _1231_ sky130_fd_sc_hd__a221o_1
XFILLER_0_77_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2577_ instance_1.mem\[0\]\[8\] _0963_ _1166_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4316_ clknet_leaf_5_clk _0542_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_4247_ clknet_leaf_5_clk _0473_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[71\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4178_ clknet_leaf_50_clk _0404_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3129_ _1511_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_81_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3480_ net422 net31 _1692_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2500_ instance_0.mem\[0\]\[59\] instance_0.mem\[1\]\[59\] instance_0.mem\[2\]\[59\]
+ instance_0.mem\[3\]\[59\] _1082_ _0974_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__mux4_1
X_2431_ instance_0.mem\[1\]\[41\] _1021_ _1030_ instance_0.mem\[3\]\[41\] VGND VGND
+ VPWR VPWR _1073_ sky130_fd_sc_hd__a22o_1
XFILLER_0_11_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2362_ instance_0.mem\[0\]\[22\] _0947_ _0979_ instance_0.mem\[2\]\[22\] _0999_ VGND
+ VGND VPWR VPWR _1023_ sky130_fd_sc_hd__a221o_1
X_2293_ instance_0.mem\[1\]\[5\] _0939_ _0958_ instance_0.mem\[3\]\[5\] VGND VGND
+ VPWR VPWR _0971_ sky130_fd_sc_hd__a22o_1
X_4101_ clknet_leaf_0_clk _0327_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_4032_ clknet_leaf_53_clk _0258_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3816_ clknet_leaf_53_clk _0042_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3747_ net454 net12 _1827_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__mux2_1
X_3678_ _1801_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2629_ net361 _1205_ _1217_ _1218_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__o22a_1
Xoutput141 net141 VGND VGND VPWR VPWR rdata[68] sky130_fd_sc_hd__clkbuf_4
Xoutput130 net130 VGND VGND VPWR VPWR rdata[58] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_58_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2980_ _1432_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__clkbuf_1
X_1931_ instance_0.rdata\[37\] instance_1.rdata\[37\] _0755_ VGND VGND VPWR VPWR _0763_
+ sky130_fd_sc_hd__mux2_1
X_1862_ instance_0.rdata\[4\] instance_1.rdata\[4\] _0722_ VGND VGND VPWR VPWR _0727_
+ sky130_fd_sc_hd__mux2_1
Xinput10 wdata[15] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_2
X_3601_ net14 net771 _1751_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__mux2_1
Xinput21 wdata[25] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_2
Xinput32 wdata[35] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_2
Xinput43 wdata[45] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput54 wdata[55] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput65 wdata[65] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_2
Xhold805 instance_0.mem\[0\]\[9\] VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__dlygate4sd3_1
Xhold816 instance_0.mem\[2\]\[68\] VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__dlygate4sd3_1
Xinput76 wr_n VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dlymetal6s2s_1
Xhold827 instance_1.mem\[0\]\[26\] VGND VGND VPWR VPWR net975 sky130_fd_sc_hd__dlygate4sd3_1
X_3532_ net389 net58 _1714_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__mux2_1
X_3463_ net798 net22 _1681_ VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__mux2_1
X_2414_ net195 _1056_ _1060_ _1061_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__o22a_1
X_3394_ net701 net66 _1644_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2345_ instance_0.mem\[1\]\[17\] _1010_ _0993_ instance_0.mem\[0\]\[17\] _0999_ VGND
+ VGND VPWR VPWR _1011_ sky130_fd_sc_hd__a221o_1
X_2276_ _0957_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__buf_4
XFILLER_0_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4015_ clknet_leaf_12_clk net244 VGND VGND VPWR VPWR instance_1.rdata\[55\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2130_ net9 net888 _0866_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__mux2_1
X_2061_ _0833_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2963_ _1423_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_60_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1914_ instance_0.rdata\[29\] instance_1.rdata\[29\] _0744_ VGND VGND VPWR VPWR _0754_
+ sky130_fd_sc_hd__mux2_1
X_2894_ _1386_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold602 instance_0.mem\[0\]\[65\] VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3515_ _1715_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__clkbuf_1
Xhold624 instance_0.mem\[0\]\[15\] VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold635 instance_1.mem\[1\]\[22\] VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__dlygate4sd3_1
Xhold613 instance_0.mem\[2\]\[32\] VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__dlygate4sd3_1
Xhold679 instance_0.mem\[1\]\[48\] VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__dlygate4sd3_1
Xhold668 instance_1.mem\[1\]\[7\] VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__dlygate4sd3_1
Xhold646 instance_0.mem\[3\]\[65\] VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__dlygate4sd3_1
Xhold657 instance_0.mem\[1\]\[2\] VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__dlygate4sd3_1
X_3446_ net774 net13 _1670_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3377_ net698 net57 _1633_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__mux2_1
X_2328_ instance_0.mem\[0\]\[13\] _0963_ _0986_ instance_0.mem\[2\]\[13\] VGND VGND
+ VPWR VPWR _0998_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_68_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2259_ _0941_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__buf_4
XFILLER_0_67_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3300_ net736 net17 _1600_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__mux2_1
X_4280_ clknet_leaf_31_clk _0506_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_3231_ net801 net61 _1563_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__mux2_1
X_3162_ _1528_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__clkbuf_1
X_2113_ net70 net925 _0855_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__mux2_1
X_3093_ _1491_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_65_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2044_ _0824_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_73_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3995_ clknet_leaf_26_clk net194 VGND VGND VPWR VPWR instance_1.rdata\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2946_ _1413_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__clkbuf_1
X_2877_ _1377_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold410 instance_1.mem\[2\]\[17\] VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__dlygate4sd3_1
Xhold421 instance_1.mem\[3\]\[7\] VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__dlygate4sd3_1
Xhold443 instance_0.mem\[2\]\[14\] VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__dlygate4sd3_1
Xhold432 instance_0.mem\[3\]\[60\] VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__dlygate4sd3_1
Xhold454 instance_0.mem\[3\]\[40\] VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__dlygate4sd3_1
Xhold465 instance_0.mem\[3\]\[7\] VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__dlygate4sd3_1
X_4478_ clknet_leaf_46_clk _0704_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[14\] sky130_fd_sc_hd__dfxtp_1
Xhold476 instance_1.mem\[0\]\[10\] VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__dlygate4sd3_1
Xhold487 instance_1.mem\[2\]\[14\] VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__dlygate4sd3_1
Xhold498 instance_0.mem\[1\]\[39\] VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__dlygate4sd3_1
X_3429_ _1658_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_0_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3780_ clknet_leaf_23_clk _0006_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[36\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_70_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2800_ _1337_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2731_ _1290_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4401_ clknet_leaf_50_clk _0627_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_2662_ net619 _1241_ _1188_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2593_ _1165_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__buf_4
X_4332_ clknet_leaf_49_clk _0558_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_4263_ clknet_leaf_44_clk _0489_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_3214_ net689 net52 _1552_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__mux2_1
X_4194_ clknet_leaf_38_clk _0420_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_3145_ net386 net16 _1519_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3076_ net60 net968 _1482_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2027_ _0815_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_82_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3978_ clknet_leaf_41_clk _0204_ VGND VGND VPWR VPWR instance_1.rdata\[18\] sky130_fd_sc_hd__dfxtp_1
X_2929_ net63 net944 _1401_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold262 instance_1.rdata\[63\] VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__dlygate4sd3_1
Xhold240 instance_1.mem\[2\]\[69\] VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__dlygate4sd3_1
Xhold251 instance_1.mem\[2\]\[31\] VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__dlygate4sd3_1
Xhold284 instance_1.mem\[2\]\[34\] VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__dlygate4sd3_1
Xhold295 instance_0.mem\[3\]\[52\] VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__dlygate4sd3_1
Xhold273 instance_1.mem\[3\]\[60\] VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput8 wdata[13] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_47_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3901_ clknet_leaf_43_clk net234 VGND VGND VPWR VPWR instance_0.rdata\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3832_ clknet_leaf_44_clk _0058_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3763_ _1845_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__clkbuf_1
X_3694_ net63 net854 _1806_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2714_ instance_1.mem\[0\]\[46\] instance_1.mem\[1\]\[46\] instance_1.mem\[2\]\[46\]
+ instance_1.mem\[3\]\[46\] _1202_ _1278_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__mux4_1
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2645_ _1165_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__clkbuf_4
X_4315_ clknet_leaf_56_clk _0541_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_2576_ net247 _1163_ _1178_ _1179_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__o22a_1
X_4246_ clknet_leaf_6_clk _0472_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[70\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4177_ clknet_leaf_54_clk _0403_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3128_ net451 net7 _1508_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__mux2_1
X_3059_ net51 net707 _1471_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_81_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2430_ net229 _1056_ _1070_ _1072_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__o22a_1
X_2361_ instance_0.mem\[1\]\[22\] _1021_ _0958_ instance_0.mem\[3\]\[22\] VGND VGND
+ VPWR VPWR _1022_ sky130_fd_sc_hd__a22o_1
X_2292_ net213 _0937_ _0969_ _0970_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__o22a_1
X_4100_ clknet_leaf_4_clk _0326_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_4031_ clknet_leaf_5_clk _0257_ VGND VGND VPWR VPWR instance_1.rdata\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3815_ clknet_leaf_5_clk _0041_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[71\] sky130_fd_sc_hd__dfxtp_1
X_3746_ _1836_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3677_ net54 net696 _1795_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__mux2_1
Xoutput120 net120 VGND VGND VPWR VPWR rdata[49] sky130_fd_sc_hd__clkbuf_4
Xoutput142 net142 VGND VGND VPWR VPWR rdata[69] sky130_fd_sc_hd__clkbuf_4
X_2628_ instance_1.mem\[1\]\[21\] _1192_ _1071_ instance_1.mem\[3\]\[21\] _1193_ VGND
+ VGND VPWR VPWR _1218_ sky130_fd_sc_hd__a221o_1
Xoutput131 net131 VGND VGND VPWR VPWR rdata[59] sky130_fd_sc_hd__clkbuf_4
X_2559_ net339 _1163_ _1164_ _1167_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__o22a_1
X_4229_ clknet_leaf_11_clk _0455_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[53\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_58_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1930_ _0762_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__buf_1
XFILLER_0_83_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1861_ _0726_ VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__buf_1
Xinput11 wdata[16] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_2
X_3600_ _1760_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__clkbuf_1
Xinput22 wdata[26] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_2
Xinput44 wdata[46] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_2
Xinput33 wdata[36] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3531_ _1723_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__clkbuf_1
Xinput55 wdata[56] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_2
Xhold806 instance_0.mem\[2\]\[65\] VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__dlygate4sd3_1
Xhold817 instance_0.mem\[0\]\[62\] VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__dlygate4sd3_1
Xinput66 wdata[66] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_2
Xhold828 instance_0.mem\[1\]\[20\] VGND VGND VPWR VPWR net976 sky130_fd_sc_hd__dlygate4sd3_1
X_3462_ _1687_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__clkbuf_1
X_2413_ instance_0.mem\[1\]\[35\] _1058_ _1040_ instance_0.mem\[2\]\[35\] _1036_ VGND
+ VGND VPWR VPWR _1061_ sky130_fd_sc_hd__a221o_1
X_3393_ _1650_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__clkbuf_1
X_2344_ _0938_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__buf_4
X_2275_ _0956_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__buf_4
X_4014_ clknet_leaf_9_clk net272 VGND VGND VPWR VPWR instance_1.rdata\[54\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3729_ net779 net74 _1827_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2060_ net541 net53 _0828_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__mux2_1
X_2962_ net70 net957 _1416_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1913_ _0753_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__buf_1
XFILLER_0_60_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2893_ net44 net837 _1379_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold603 instance_0.mem\[2\]\[41\] VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__dlygate4sd3_1
Xhold614 instance_0.mem\[2\]\[38\] VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__dlygate4sd3_1
X_3514_ net710 net49 _1714_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold625 instance_0.mem\[0\]\[21\] VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__dlygate4sd3_1
Xhold636 instance_0.mem\[2\]\[23\] VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold647 instance_1.mem\[0\]\[7\] VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__dlygate4sd3_1
X_3445_ _1678_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__clkbuf_1
Xhold669 instance_0.mem\[1\]\[68\] VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__dlygate4sd3_1
Xhold658 instance_1.mem\[2\]\[26\] VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__dlygate4sd3_1
X_3376_ _1641_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__clkbuf_1
X_2327_ net159 _0990_ _0995_ _0997_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__o22a_1
X_2258_ _0940_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_68_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2189_ net40 net969 _0899_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_23_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_89_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3230_ _1564_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__clkbuf_1
X_3161_ net782 net24 _1519_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__mux2_1
X_2112_ _0861_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__clkbuf_1
X_3092_ net68 net964 _1482_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2043_ net428 net44 _0817_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3994_ clknet_leaf_29_clk net178 VGND VGND VPWR VPWR instance_1.rdata\[34\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_73_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2945_ net72 net947 _1334_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__mux2_1
X_2876_ net35 net648 _1368_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold411 instance_0.mem\[3\]\[49\] VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__dlygate4sd3_1
Xhold400 instance_1.rdata\[14\] VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__dlygate4sd3_1
Xhold433 instance_1.mem\[2\]\[39\] VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__dlygate4sd3_1
Xhold422 instance_1.mem\[3\]\[39\] VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__dlygate4sd3_1
Xhold444 instance_0.mem\[3\]\[30\] VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__dlygate4sd3_1
Xhold477 instance_1.mem\[0\]\[0\] VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__dlygate4sd3_1
X_4477_ clknet_leaf_43_clk _0703_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[13\] sky130_fd_sc_hd__dfxtp_1
Xhold466 instance_1.mem\[0\]\[5\] VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__dlygate4sd3_1
Xhold455 instance_1.mem\[3\]\[21\] VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__dlygate4sd3_1
Xhold499 instance_0.mem\[1\]\[67\] VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__dlygate4sd3_1
X_3428_ _1669_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__clkbuf_1
Xhold488 instance_1.mem\[1\]\[58\] VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__dlygate4sd3_1
X_3359_ _1632_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2730_ net564 _1289_ _1188_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__mux2_1
X_2661_ instance_1.mem\[0\]\[31\] instance_1.mem\[1\]\[31\] instance_1.mem\[2\]\[31\]
+ instance_1.mem\[3\]\[31\] _1202_ _1130_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__mux4_1
X_4400_ clknet_leaf_49_clk _0626_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2592_ _0803_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__buf_4
X_4331_ clknet_leaf_49_clk _0557_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_4262_ clknet_leaf_46_clk _0488_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_3213_ _1555_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4193_ clknet_leaf_40_clk _0419_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_3144_ _1496_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__buf_4
X_3075_ _1415_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__buf_4
X_2026_ net528 net35 _0806_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3977_ clknet_leaf_41_clk net352 VGND VGND VPWR VPWR instance_1.rdata\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2928_ _1404_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__clkbuf_1
X_2859_ _1334_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__buf_4
Xhold230 instance_0.rdata\[43\] VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__dlygate4sd3_1
Xhold252 instance_1.mem\[1\]\[1\] VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__dlygate4sd3_1
Xhold241 instance_0.mem\[3\]\[59\] VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__dlygate4sd3_1
Xhold263 instance_0.mem\[3\]\[39\] VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__dlygate4sd3_1
Xhold274 instance_0.mem\[3\]\[34\] VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__dlygate4sd3_1
Xhold285 instance_0.rdata\[55\] VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__dlygate4sd3_1
Xhold296 instance_1.mem\[3\]\[0\] VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput9 wdata[14] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_47_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3900_ clknet_leaf_42_clk net160 VGND VGND VPWR VPWR instance_0.rdata\[12\] sky130_fd_sc_hd__dfxtp_1
X_3831_ clknet_leaf_43_clk _0057_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3762_ net533 net20 _1838_ VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3693_ _1809_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__clkbuf_1
X_2713_ _0945_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__buf_4
X_2644_ instance_1.mem\[3\]\[26\] _1184_ _1197_ instance_1.mem\[2\]\[26\] VGND VGND
+ VPWR VPWR _1229_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_10_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2575_ instance_1.mem\[0\]\[7\] _1145_ _1127_ instance_1.mem\[2\]\[7\] _1166_ VGND
+ VGND VPWR VPWR _1179_ sky130_fd_sc_hd__a221o_1
X_4314_ clknet_leaf_3_clk _0540_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[66\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4245_ clknet_leaf_56_clk _0471_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_4176_ clknet_leaf_54_clk _0402_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3127_ _1510_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__clkbuf_1
X_3058_ _1473_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__clkbuf_1
X_2009_ _0805_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_81_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_53_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_53_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_68_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2360_ _0938_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_16_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2291_ instance_0.mem\[3\]\[4\] _0957_ _0950_ instance_0.mem\[2\]\[4\] _0960_ VGND
+ VGND VPWR VPWR _0970_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4030_ clknet_leaf_6_clk net304 VGND VGND VPWR VPWR instance_1.rdata\[70\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_44_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_44_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_74_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_25_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3814_ clknet_leaf_6_clk _0040_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[70\] sky130_fd_sc_hd__dfxtp_1
X_3745_ net865 net11 _1827_ VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput110 net110 VGND VGND VPWR VPWR rdata[3] sky130_fd_sc_hd__clkbuf_4
X_3676_ _1800_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput132 net132 VGND VGND VPWR VPWR rdata[5] sky130_fd_sc_hd__clkbuf_4
Xoutput143 net143 VGND VGND VPWR VPWR rdata[6] sky130_fd_sc_hd__clkbuf_4
Xoutput121 net121 VGND VGND VPWR VPWR rdata[4] sky130_fd_sc_hd__clkbuf_4
X_2627_ instance_1.mem\[0\]\[21\] _1190_ _1197_ instance_1.mem\[2\]\[21\] VGND VGND
+ VPWR VPWR _1217_ sky130_fd_sc_hd__a22o_1
XFILLER_0_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_34_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2558_ instance_1.mem\[1\]\[2\] _1122_ _1154_ instance_1.mem\[0\]\[2\] _1166_ VGND
+ VGND VPWR VPWR _1167_ sky130_fd_sc_hd__a221o_1
X_2489_ instance_0.mem\[2\]\[56\] _0986_ _0942_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__a21o_1
X_4228_ clknet_leaf_12_clk _0454_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_4159_ clknet_leaf_13_clk _0385_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[55\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_43_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_35_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_35_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_13_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_52_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_61_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_26_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_26_clk sky130_fd_sc_hd__clkbuf_8
X_1860_ instance_0.rdata\[3\] instance_1.rdata\[3\] _0722_ VGND VGND VPWR VPWR _0726_
+ sky130_fd_sc_hd__mux2_1
Xinput12 wdata[17] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_2
Xinput34 wdata[37] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_2
Xinput45 wdata[47] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__buf_2
X_3530_ net512 net57 _1714_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__mux2_1
Xinput23 wdata[27] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_2
Xinput67 wdata[67] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold818 instance_0.mem\[1\]\[26\] VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__dlygate4sd3_1
Xhold807 instance_0.mem\[0\]\[37\] VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__dlygate4sd3_1
Xinput56 wdata[57] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_70_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold829 instance_0.mem\[0\]\[71\] VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__dlygate4sd3_1
X_3461_ net503 net21 _1681_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__mux2_1
X_2412_ instance_0.mem\[0\]\[35\] _1042_ _1030_ instance_0.mem\[3\]\[35\] VGND VGND
+ VPWR VPWR _1060_ sky130_fd_sc_hd__a22o_1
X_3392_ net395 net65 _1644_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__mux2_1
X_2343_ instance_0.mem\[3\]\[17\] _0991_ _1008_ instance_0.mem\[2\]\[17\] VGND VGND
+ VPWR VPWR _1009_ sky130_fd_sc_hd__a22o_1
XFILLER_0_58_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2274_ _0955_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__clkbuf_4
X_4013_ clknet_leaf_11_clk _0239_ VGND VGND VPWR VPWR instance_1.rdata\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_17_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_47_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1989_ _0793_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_1
X_3728_ _0805_ VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__buf_4
X_3659_ _1791_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_5_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2961_ _1422_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__clkbuf_1
X_1912_ instance_0.rdata\[28\] instance_1.rdata\[28\] _0744_ VGND VGND VPWR VPWR _0753_
+ sky130_fd_sc_hd__mux2_1
X_2892_ _1385_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_60_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold626 instance_0.mem\[3\]\[18\] VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold604 instance_1.mem\[1\]\[37\] VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__dlygate4sd3_1
X_4493_ clknet_leaf_31_clk _0719_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_3513_ _1658_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__buf_4
Xhold615 instance_0.mem\[1\]\[40\] VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__dlygate4sd3_1
Xhold648 instance_1.mem\[0\]\[52\] VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__dlygate4sd3_1
Xhold659 instance_0.mem\[0\]\[5\] VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__dlygate4sd3_1
X_3444_ net620 net12 _1670_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__mux2_1
Xhold637 instance_0.mem\[1\]\[64\] VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_6_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_8
X_3375_ net556 net56 _1633_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__mux2_1
X_2326_ instance_0.mem\[1\]\[12\] _0965_ _0993_ instance_0.mem\[0\]\[12\] _0996_ VGND
+ VGND VPWR VPWR _0997_ sky130_fd_sc_hd__a221o_1
X_2257_ _0720_ _0801_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__or2b_1
XFILLER_0_79_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2188_ _0901_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_89_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3160_ _1527_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__clkbuf_1
X_2111_ net59 net807 _0855_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__mux2_1
X_3091_ _1490_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__clkbuf_1
Xhold1 instance_0.rdata\[51\] VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2042_ _0823_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_65_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3993_ clknet_leaf_30_clk net344 VGND VGND VPWR VPWR instance_1.rdata\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2944_ _1412_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2875_ _1376_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold401 instance_1.mem\[1\]\[64\] VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__dlygate4sd3_1
Xhold412 instance_0.mem\[1\]\[49\] VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__dlygate4sd3_1
Xhold445 instance_1.mem\[1\]\[4\] VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__dlygate4sd3_1
Xhold423 instance_1.mem\[2\]\[24\] VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__dlygate4sd3_1
Xhold434 instance_1.mem\[2\]\[56\] VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__dlygate4sd3_1
Xhold478 instance_0.mem\[0\]\[34\] VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__dlygate4sd3_1
Xhold456 instance_0.mem\[1\]\[55\] VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__dlygate4sd3_1
Xhold467 instance_0.mem\[1\]\[14\] VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__dlygate4sd3_1
X_4476_ clknet_leaf_48_clk _0702_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_3427_ net835 net75 _1659_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold489 instance_0.mem\[2\]\[46\] VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__dlygate4sd3_1
X_3358_ net566 net47 _1622_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__mux2_1
X_2309_ net191 _0937_ _0981_ _0983_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__o22a_1
X_3289_ net545 net11 _1589_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2660_ net287 _1232_ _1239_ _1240_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2591_ instance_1.mem\[0\]\[11\] _1190_ _1105_ instance_1.mem\[2\]\[11\] VGND VGND
+ VPWR VPWR _1191_ sky130_fd_sc_hd__a22o_1
X_4330_ clknet_leaf_48_clk _0556_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_4261_ clknet_leaf_43_clk _0487_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_3212_ net498 net51 _1552_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4192_ clknet_leaf_45_clk _0418_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_3143_ _1518_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3074_ _1481_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2025_ _0814_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3976_ clknet_leaf_45_clk net268 VGND VGND VPWR VPWR instance_1.rdata\[16\] sky130_fd_sc_hd__dfxtp_1
X_2927_ net62 net936 _1401_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2858_ _1367_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__clkbuf_1
X_2789_ instance_1.mem\[0\]\[70\] _0962_ _1103_ instance_1.mem\[2\]\[70\] _1165_ VGND
+ VGND VPWR VPWR _1330_ sky130_fd_sc_hd__a221o_1
Xhold220 _0223_ VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold231 instance_1.mem\[3\]\[65\] VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__dlygate4sd3_1
Xhold253 instance_1.mem\[1\]\[10\] VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__dlygate4sd3_1
Xhold242 instance_0.mem\[3\]\[12\] VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__dlygate4sd3_1
Xhold275 instance_0.mem\[3\]\[35\] VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__dlygate4sd3_1
Xhold286 instance_0.mem\[0\]\[39\] VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__dlygate4sd3_1
X_4459_ clknet_leaf_56_clk _0685_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[67\] sky130_fd_sc_hd__dfxtp_1
Xhold264 instance_0.mem\[3\]\[8\] VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__dlygate4sd3_1
Xhold297 instance_0.mem\[2\]\[30\] VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3830_ clknet_leaf_45_clk _0056_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3761_ _1844_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__clkbuf_1
X_2712_ net255 _1261_ _1276_ _1277_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__o22a_1
X_3692_ net62 net657 _1806_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2643_ net355 _1205_ _1227_ _1228_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__o22a_1
XFILLER_0_77_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2574_ instance_1.mem\[1\]\[7\] _1111_ _1177_ instance_1.mem\[3\]\[7\] VGND VGND
+ VPWR VPWR _1178_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_10_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4313_ clknet_leaf_57_clk _0539_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[65\] sky130_fd_sc_hd__dfxtp_1
X_4244_ clknet_leaf_5_clk _0470_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_4175_ clknet_leaf_5_clk _0401_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[71\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3126_ net893 net6 _1508_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__mux2_1
X_3057_ net50 net938 _1471_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2008_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__buf_4
XFILLER_0_9_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3959_ clknet_leaf_5_clk net264 VGND VGND VPWR VPWR instance_0.rdata\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2290_ instance_0.mem\[1\]\[4\] _0939_ _0963_ instance_0.mem\[0\]\[4\] VGND VGND
+ VPWR VPWR _0969_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3813_ clknet_leaf_56_clk _0039_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_3744_ _1835_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__clkbuf_1
X_3675_ net53 net864 _1795_ VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__mux2_1
Xoutput100 net100 VGND VGND VPWR VPWR rdata[30] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2626_ net337 _1205_ _1215_ _1216_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__o22a_1
Xoutput111 net111 VGND VGND VPWR VPWR rdata[40] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput122 net122 VGND VGND VPWR VPWR rdata[50] sky130_fd_sc_hd__clkbuf_4
Xoutput133 net133 VGND VGND VPWR VPWR rdata[60] sky130_fd_sc_hd__clkbuf_4
Xoutput144 net144 VGND VGND VPWR VPWR rdata[70] sky130_fd_sc_hd__clkbuf_4
X_2557_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__clkbuf_4
X_2488_ _1115_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__clkbuf_1
X_4227_ clknet_leaf_9_clk _0453_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_4158_ clknet_leaf_9_clk _0384_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[54\] sky130_fd_sc_hd__dfxtp_1
X_3109_ net621 net37 _1497_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__mux2_1
X_4089_ clknet_leaf_14_clk _0315_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[57\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput13 wdata[18] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_2
Xinput35 wdata[38] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_2
Xinput46 wdata[48] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput24 wdata[28] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_2
XFILLER_0_3_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold808 instance_0.mem\[0\]\[63\] VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__dlygate4sd3_1
Xinput68 wdata[68] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__buf_2
Xinput57 wdata[58] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_2
Xhold819 instance_0.mem\[1\]\[33\] VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__dlygate4sd3_1
X_3460_ _1686_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__clkbuf_1
X_2411_ net285 _1056_ _1057_ _1059_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__o22a_1
X_3391_ _1649_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__clkbuf_1
X_2342_ _0978_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__buf_4
X_4012_ clknet_leaf_14_clk net240 VGND VGND VPWR VPWR instance_1.rdata\[52\] sky130_fd_sc_hd__dfxtp_1
X_2273_ net1 net2 VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__and2_1
XFILLER_0_59_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3727_ _1826_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__clkbuf_1
X_1988_ instance_0.rdata\[64\] instance_1.rdata\[64\] _0788_ VGND VGND VPWR VPWR _0793_
+ sky130_fd_sc_hd__mux2_1
X_3658_ net44 net416 _1784_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__mux2_1
X_2609_ _1204_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__clkbuf_1
X_3589_ net8 net797 _1751_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_54_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2960_ net59 net962 _1416_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__mux2_1
X_2891_ net43 net474 _1379_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__mux2_1
X_1911_ _0752_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3512_ _1713_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__clkbuf_1
X_4492_ clknet_leaf_33_clk _0718_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold605 instance_0.mem\[1\]\[28\] VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__dlygate4sd3_1
Xhold616 instance_0.mem\[2\]\[48\] VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__dlygate4sd3_1
Xhold627 instance_0.mem\[1\]\[37\] VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3443_ _1677_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__clkbuf_1
Xhold649 instance_1.mem\[0\]\[13\] VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__dlygate4sd3_1
Xhold638 instance_1.mem\[3\]\[56\] VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__dlygate4sd3_1
X_3374_ _1640_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__clkbuf_1
X_2325_ _0951_ _0952_ instance_0.mem\[3\]\[12\] VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__and3_1
X_2256_ _0938_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_68_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2187_ net39 net531 _0899_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3090_ net67 net825 _1482_ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__mux2_1
X_2110_ _0860_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
Xhold2 _0165_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2041_ net692 net43 _0817_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3992_ clknet_leaf_31_clk net374 VGND VGND VPWR VPWR instance_1.rdata\[32\] sky130_fd_sc_hd__dfxtp_1
X_2943_ net71 net709 _1334_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2874_ net34 net775 _1368_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold402 instance_0.mem\[3\]\[6\] VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold424 instance_1.mem\[1\]\[9\] VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold413 instance_0.mem\[3\]\[24\] VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__dlygate4sd3_1
Xhold435 instance_0.mem\[3\]\[46\] VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__dlygate4sd3_1
Xhold457 instance_1.mem\[2\]\[42\] VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__dlygate4sd3_1
Xhold446 instance_1.mem\[3\]\[15\] VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__dlygate4sd3_1
X_4475_ clknet_leaf_49_clk _0701_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold468 instance_1.mem\[1\]\[59\] VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__dlygate4sd3_1
Xhold479 instance_1.mem\[3\]\[42\] VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3426_ _1668_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__clkbuf_1
X_3357_ _1631_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__clkbuf_1
X_2308_ instance_0.mem\[1\]\[8\] _0965_ _0979_ instance_0.mem\[2\]\[8\] _0982_ VGND
+ VGND VPWR VPWR _0983_ sky130_fd_sc_hd__a221o_1
X_3288_ _1595_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__clkbuf_1
X_2239_ net66 net793 _0921_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2590_ _0962_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4260_ clknet_leaf_48_clk _0486_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_4191_ clknet_leaf_44_clk _0417_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_3211_ _1554_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_78_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3142_ net829 net14 _1508_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__mux2_1
XFILLER_0_66_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3073_ net58 net670 _1471_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__mux2_1
X_2024_ net752 net34 _0806_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3975_ clknet_leaf_44_clk _0201_ VGND VGND VPWR VPWR instance_1.rdata\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2926_ _1403_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2857_ net25 net668 _1357_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold210 _0195_ VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__dlygate4sd3_1
X_2788_ instance_1.mem\[1\]\[70\] _0965_ _0991_ instance_1.mem\[3\]\[70\] VGND VGND
+ VPWR VPWR _1329_ sky130_fd_sc_hd__a22o_1
Xhold232 instance_0.rdata\[39\] VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold243 instance_1.mem\[2\]\[67\] VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__dlygate4sd3_1
Xhold221 instance_1.rdata\[27\] VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__dlygate4sd3_1
Xhold276 instance_0.mem\[2\]\[39\] VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__dlygate4sd3_1
Xhold287 instance_1.mem\[1\]\[49\] VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__dlygate4sd3_1
Xhold254 instance_1.mem\[1\]\[14\] VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4458_ clknet_leaf_3_clk _0684_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[66\] sky130_fd_sc_hd__dfxtp_1
Xhold265 instance_1.mem\[1\]\[71\] VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__dlygate4sd3_1
X_3409_ net431 net4 _1659_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__mux2_1
Xhold298 instance_0.mem\[1\]\[59\] VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__dlygate4sd3_1
X_4389_ clknet_leaf_1_clk _0615_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[69\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_86_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3760_ net744 net19 _1838_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__mux2_1
X_2711_ instance_1.mem\[1\]\[45\] _1244_ _1086_ instance_1.mem\[0\]\[45\] _1263_ VGND
+ VGND VPWR VPWR _1277_ sky130_fd_sc_hd__a221o_1
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3691_ _1808_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2642_ instance_1.mem\[1\]\[25\] _1192_ _1154_ instance_1.mem\[0\]\[25\] _1193_ VGND
+ VGND VPWR VPWR _1228_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_10_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2573_ _0956_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__buf_4
X_4312_ clknet_leaf_3_clk _0538_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_4243_ clknet_leaf_56_clk _0469_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_4174_ clknet_leaf_6_clk _0400_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[70\] sky130_fd_sc_hd__dfxtp_1
X_3125_ _1509_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3056_ _1472_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2007_ _0801_ _0803_ _0720_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__and3b_1
XFILLER_0_77_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3958_ clknet_leaf_6_clk net306 VGND VGND VPWR VPWR instance_0.rdata\[70\] sky130_fd_sc_hd__dfxtp_1
X_3889_ clknet_leaf_47_clk net298 VGND VGND VPWR VPWR instance_0.rdata\[1\] sky130_fd_sc_hd__dfxtp_1
X_2909_ _1394_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3812_ clknet_leaf_5_clk _0038_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[68\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3743_ net722 net10 _1827_ VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3674_ _1799_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__clkbuf_1
X_2625_ instance_1.mem\[2\]\[20\] _0986_ _1166_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__a21o_1
Xoutput101 net101 VGND VGND VPWR VPWR rdata[31] sky130_fd_sc_hd__buf_2
Xoutput112 net112 VGND VGND VPWR VPWR rdata[41] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput134 net134 VGND VGND VPWR VPWR rdata[61] sky130_fd_sc_hd__clkbuf_4
Xoutput123 net123 VGND VGND VPWR VPWR rdata[51] sky130_fd_sc_hd__clkbuf_4
Xoutput145 net145 VGND VGND VPWR VPWR rdata[71] sky130_fd_sc_hd__clkbuf_4
X_2556_ _0721_ _0801_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__nand2_4
X_2487_ net433 _1114_ _0935_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__mux2_1
X_4226_ clknet_leaf_13_clk _0452_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_4157_ clknet_leaf_11_clk _0383_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_3108_ _1500_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__clkbuf_1
X_4088_ clknet_leaf_7_clk _0314_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_3039_ _1463_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput36 wdata[39] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_2
Xinput14 wdata[19] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_2
Xinput25 wdata[29] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_2
Xinput47 wdata[49] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_2
Xhold809 instance_0.mem\[2\]\[6\] VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__dlygate4sd3_1
Xinput69 wdata[69] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__clkbuf_2
Xinput58 wdata[59] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_2
X_2410_ instance_0.mem\[1\]\[34\] _1058_ _1048_ instance_0.mem\[0\]\[34\] _1036_ VGND
+ VGND VPWR VPWR _1059_ sky130_fd_sc_hd__a221o_1
X_3390_ net641 net64 _1644_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2341_ net331 _0990_ _1005_ _1007_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__o22a_1
X_2272_ net319 _0937_ _0943_ _0954_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__o22a_1
X_4011_ clknet_leaf_8_clk _0237_ VGND VGND VPWR VPWR instance_1.rdata\[51\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_63_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1987_ _0792_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__clkbuf_1
X_3726_ net816 net73 _0850_ VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3657_ _1790_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__clkbuf_1
X_2608_ net506 _1203_ _1188_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3588_ _1754_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2539_ instance_0.mem\[0\]\[70\] _1145_ _1127_ instance_0.mem\[2\]\[70\] _1128_ VGND
+ VGND VPWR VPWR _1152_ sky130_fd_sc_hd__a221o_1
X_4209_ clknet_leaf_30_clk _0435_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_48 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1910_ instance_0.rdata\[27\] instance_1.rdata\[27\] _0744_ VGND VGND VPWR VPWR _0752_
+ sky130_fd_sc_hd__mux2_1
X_2890_ _1384_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3511_ net559 net47 _1703_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__mux2_1
Xhold606 instance_1.mem\[3\]\[50\] VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__dlygate4sd3_1
Xhold617 instance_0.mem\[1\]\[5\] VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__dlygate4sd3_1
X_4491_ clknet_leaf_32_clk _0717_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_3442_ net464 net11 _1670_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__mux2_1
Xhold628 instance_1.mem\[0\]\[12\] VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__dlygate4sd3_1
Xhold639 instance_0.mem\[1\]\[9\] VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__dlygate4sd3_1
X_3373_ net582 net55 _1633_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2324_ instance_0.mem\[2\]\[12\] _0986_ _0942_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2255_ _0803_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_68_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2186_ _0900_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_23_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3709_ _1817_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold3 instance_0.rdata\[46\] VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dlygate4sd3_1
X_2040_ _0822_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3991_ clknet_leaf_34_clk _0217_ VGND VGND VPWR VPWR instance_1.rdata\[31\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_73_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2942_ _1411_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2873_ _1375_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__clkbuf_1
Xhold403 instance_0.mem\[2\]\[35\] VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__dlygate4sd3_1
Xhold414 instance_1.mem\[0\]\[67\] VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__dlygate4sd3_1
Xhold425 instance_1.mem\[0\]\[15\] VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold436 instance_1.mem\[1\]\[27\] VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__dlygate4sd3_1
Xhold458 instance_0.mem\[0\]\[49\] VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__dlygate4sd3_1
X_4474_ clknet_leaf_46_clk _0700_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[10\] sky130_fd_sc_hd__dfxtp_1
Xhold447 instance_1.mem\[1\]\[19\] VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__dlygate4sd3_1
Xhold469 instance_0.mem\[1\]\[21\] VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__dlygate4sd3_1
X_3425_ net412 net74 _1659_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__mux2_1
X_3356_ net672 net46 _1622_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__mux2_1
X_3287_ net403 net10 _1589_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__mux2_1
X_2307_ _0951_ _0952_ instance_0.mem\[3\]\[8\] VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__and3_1
X_2238_ _0927_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__clkbuf_1
X_2169_ _0891_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4190_ clknet_leaf_46_clk _0416_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_3210_ net384 net50 _1552_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__mux2_1
XFILLER_0_66_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3141_ _1517_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_78_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3072_ _1480_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2023_ _0813_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3974_ clknet_leaf_45_clk _0200_ VGND VGND VPWR VPWR instance_1.rdata\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2925_ net61 net747 _1401_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2856_ _1366_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2787_ _1328_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__clkbuf_1
Xhold211 instance_0.rdata\[62\] VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__dlygate4sd3_1
Xhold200 _0141_ VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__dlygate4sd3_1
Xhold233 instance_1.mem\[2\]\[46\] VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__dlygate4sd3_1
Xhold222 _0213_ VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__dlygate4sd3_1
Xhold244 instance_1.mem\[3\]\[31\] VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__dlygate4sd3_1
Xhold266 instance_0.rdata\[45\] VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__dlygate4sd3_1
X_4457_ clknet_leaf_57_clk _0683_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[65\] sky130_fd_sc_hd__dfxtp_1
Xhold255 instance_1.mem\[2\]\[15\] VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__dlygate4sd3_1
Xhold277 instance_1.mem\[3\]\[1\] VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold299 instance_1.mem\[3\]\[34\] VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__dlygate4sd3_1
Xhold288 instance_1.rdata\[65\] VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__dlygate4sd3_1
X_3408_ _1658_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__buf_4
X_4388_ clknet_leaf_4_clk _0614_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_3339_ _1577_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_86_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_56_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_56_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_47_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2710_ instance_1.mem\[3\]\[45\] _0988_ _1248_ instance_1.mem\[2\]\[45\] VGND VGND
+ VPWR VPWR _1276_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3690_ net61 net935 _1806_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2641_ instance_1.mem\[3\]\[25\] _1184_ _1197_ instance_1.mem\[2\]\[25\] VGND VGND
+ VPWR VPWR _1227_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_10_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2572_ _1176_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4311_ clknet_leaf_55_clk _0537_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[63\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4242_ clknet_leaf_2_clk _0468_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_4173_ clknet_leaf_0_clk _0399_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_3124_ net439 net5 _1508_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_2_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3055_ net49 net703 _1471_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_47_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_47_clk sky130_fd_sc_hd__clkbuf_8
X_2006_ _0802_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_18_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3957_ clknet_leaf_0_clk net176 VGND VGND VPWR VPWR instance_0.rdata\[69\] sky130_fd_sc_hd__dfxtp_1
X_2908_ net52 net847 _1390_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__mux2_1
X_3888_ clknet_leaf_54_clk net320 VGND VGND VPWR VPWR instance_0.rdata\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2839_ net16 net976 _1357_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_38_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_38_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_29_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_29_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_86_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3811_ clknet_leaf_56_clk _0037_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[67\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3742_ _1834_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3673_ net52 net845 _1795_ VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2624_ instance_1.mem\[1\]\[20\] _1102_ _1086_ instance_1.mem\[0\]\[20\] _1214_ VGND
+ VGND VPWR VPWR _1215_ sky130_fd_sc_hd__a221o_1
Xoutput113 net113 VGND VGND VPWR VPWR rdata[42] sky130_fd_sc_hd__clkbuf_4
Xoutput124 net124 VGND VGND VPWR VPWR rdata[52] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput102 net102 VGND VGND VPWR VPWR rdata[32] sky130_fd_sc_hd__buf_2
Xoutput146 net146 VGND VGND VPWR VPWR rdata[7] sky130_fd_sc_hd__clkbuf_4
Xoutput135 net135 VGND VGND VPWR VPWR rdata[62] sky130_fd_sc_hd__clkbuf_4
X_2555_ instance_1.mem\[3\]\[2\] _1016_ _1105_ instance_1.mem\[2\]\[2\] VGND VGND
+ VPWR VPWR _1164_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2486_ instance_0.mem\[0\]\[55\] instance_0.mem\[1\]\[55\] instance_0.mem\[2\]\[55\]
+ instance_0.mem\[3\]\[55\] _1082_ _0974_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__mux4_1
X_4225_ clknet_leaf_18_clk _0451_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_4156_ clknet_leaf_12_clk _0382_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_3107_ net678 net26 _1497_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__mux2_1
X_4087_ clknet_leaf_13_clk _0313_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_3038_ net40 net948 _1460_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_12_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_30_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput15 wdata[1] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_2
Xinput26 wdata[2] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_2
Xinput37 wdata[3] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput59 wdata[5] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_2
Xinput48 wdata[4] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_2
XFILLER_0_20_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2340_ instance_0.mem\[1\]\[16\] _0965_ _0979_ instance_0.mem\[2\]\[16\] _1006_ VGND
+ VGND VPWR VPWR _1007_ sky130_fd_sc_hd__a221o_1
XFILLER_0_20_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2271_ instance_0.mem\[0\]\[0\] _0947_ _0950_ instance_0.mem\[2\]\[0\] _0953_ VGND
+ VGND VPWR VPWR _0954_ sky130_fd_sc_hd__a221o_1
X_4010_ clknet_leaf_14_clk net342 VGND VGND VPWR VPWR instance_1.rdata\[50\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_87_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1986_ instance_0.rdata\[63\] instance_1.rdata\[63\] _0788_ VGND VGND VPWR VPWR _0792_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3725_ _1825_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_9_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_8
X_3656_ net43 net610 _1784_ VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__mux2_1
X_2607_ instance_1.mem\[0\]\[15\] instance_1.mem\[1\]\[15\] instance_1.mem\[2\]\[15\]
+ instance_1.mem\[3\]\[15\] _1202_ _1130_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__mux4_1
X_3587_ net7 net776 _1751_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2538_ instance_0.mem\[1\]\[70\] _1111_ _1108_ instance_0.mem\[3\]\[70\] VGND VGND
+ VPWR VPWR _1151_ sky130_fd_sc_hd__a22o_1
X_2469_ instance_0.mem\[0\]\[51\] _0962_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__and2_1
X_4208_ clknet_leaf_31_clk _0434_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_4139_ clknet_leaf_27_clk _0365_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_3_4__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_60_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_60_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3510_ _1712_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__clkbuf_1
Xhold618 instance_1.mem\[1\]\[33\] VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4490_ clknet_leaf_32_clk _0716_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[26\] sky130_fd_sc_hd__dfxtp_1
Xhold607 instance_1.mem\[0\]\[28\] VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__dlygate4sd3_1
Xhold629 instance_1.mem\[0\]\[44\] VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__dlygate4sd3_1
X_3441_ _1676_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__clkbuf_1
X_3372_ _1639_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__clkbuf_1
X_2323_ net203 _0990_ _0992_ _0994_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__o22a_1
X_2254_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_68_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2185_ net38 net914 _0899_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1969_ instance_0.rdata\[55\] instance_1.rdata\[55\] _0777_ VGND VGND VPWR VPWR _0783_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3708_ net71 net712 _1739_ VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__mux2_1
X_3639_ net34 net858 _1773_ VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_89_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_9_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold4 _0160_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_65_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3990_ clknet_leaf_23_clk net288 VGND VGND VPWR VPWR instance_1.rdata\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_73_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2941_ net69 net746 _1401_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__mux2_1
X_2872_ net33 net727 _1368_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold415 instance_1.mem\[2\]\[62\] VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__dlygate4sd3_1
X_4473_ clknet_leaf_50_clk _0699_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[9\] sky130_fd_sc_hd__dfxtp_1
Xhold426 instance_1.mem\[3\]\[66\] VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__dlygate4sd3_1
Xhold404 instance_0.mem\[3\]\[29\] VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__dlygate4sd3_1
Xhold437 instance_0.mem\[2\]\[33\] VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__dlygate4sd3_1
X_3424_ _1667_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__clkbuf_1
Xhold448 instance_1.mem\[3\]\[22\] VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__dlygate4sd3_1
Xhold459 instance_0.mem\[1\]\[54\] VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3355_ _1630_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__clkbuf_1
X_3286_ _1594_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__clkbuf_1
X_2306_ instance_0.mem\[0\]\[8\] _0963_ _0942_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__a21o_1
X_2237_ net65 net750 _0921_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__mux2_1
X_2168_ net29 net886 _0888_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2099_ _0853_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_0_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3140_ net429 net13 _1508_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_78_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3071_ net57 net909 _1471_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__mux2_1
X_2022_ net833 net33 _0806_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3973_ clknet_leaf_43_clk net284 VGND VGND VPWR VPWR instance_1.rdata\[13\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2924_ _1402_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2855_ net24 net753 _1357_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2786_ net492 _1327_ _1158_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold201 instance_1.rdata\[11\] VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold212 _0176_ VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__dlygate4sd3_1
Xhold223 instance_1.rdata\[19\] VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__dlygate4sd3_1
Xhold234 instance_1.mem\[2\]\[18\] VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_68_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold256 instance_1.mem\[1\]\[67\] VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__dlygate4sd3_1
Xhold267 instance_1.mem\[1\]\[0\] VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__dlygate4sd3_1
X_4456_ clknet_leaf_3_clk _0682_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[64\] sky130_fd_sc_hd__dfxtp_1
Xhold278 instance_0.rdata\[61\] VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold245 instance_0.mem\[3\]\[31\] VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__dlygate4sd3_1
Xhold289 instance_1.mem\[1\]\[39\] VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__dlygate4sd3_1
X_4387_ clknet_leaf_1_clk _0613_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_3407_ _1657_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__buf_4
X_3338_ _1621_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_5_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3269_ _1585_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_77_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_86_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold790 instance_0.mem\[2\]\[51\] VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_75_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2640_ net329 _1205_ _1225_ _1226_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__o22a_1
XFILLER_0_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2571_ net520 _1175_ _1159_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__mux2_1
X_4310_ clknet_leaf_2_clk _0536_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[62\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4241_ clknet_leaf_57_clk _0467_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[65\] sky130_fd_sc_hd__dfxtp_1
X_4172_ clknet_leaf_4_clk _0398_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_3123_ _1496_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__buf_4
XFILLER_0_89_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3054_ _1415_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__buf_4
X_2005_ net2 net1 VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3956_ clknet_leaf_4_clk net266 VGND VGND VPWR VPWR instance_0.rdata\[68\] sky130_fd_sc_hd__dfxtp_1
X_2907_ _1393_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3887_ clknet_leaf_5_clk _0113_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[71\] sky130_fd_sc_hd__dfxtp_1
X_2838_ _1334_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__buf_4
X_2769_ _1316_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4439_ clknet_leaf_19_clk _0665_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[47\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_44_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3810_ clknet_leaf_2_clk _0036_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_3741_ net402 net9 _1827_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__mux2_1
XFILLER_0_67_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3672_ _1798_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2623_ _0973_ _0945_ instance_1.mem\[3\]\[20\] VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__and3_1
Xoutput114 net114 VGND VGND VPWR VPWR rdata[43] sky130_fd_sc_hd__clkbuf_4
Xoutput103 net103 VGND VGND VPWR VPWR rdata[33] sky130_fd_sc_hd__buf_2
X_2554_ _1159_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__buf_4
Xoutput125 net125 VGND VGND VPWR VPWR rdata[53] sky130_fd_sc_hd__clkbuf_4
Xoutput136 net136 VGND VGND VPWR VPWR rdata[63] sky130_fd_sc_hd__clkbuf_4
Xoutput147 net147 VGND VGND VPWR VPWR rdata[8] sky130_fd_sc_hd__clkbuf_4
X_2485_ net161 _1092_ _1112_ _1113_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__o22a_1
X_4224_ clknet_leaf_23_clk _0450_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_4155_ clknet_leaf_8_clk _0381_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_3106_ _1499_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__clkbuf_1
X_4086_ clknet_leaf_10_clk _0312_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[54\] sky130_fd_sc_hd__dfxtp_1
X_3037_ _1462_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3939_ clknet_leaf_9_clk net150 VGND VGND VPWR VPWR instance_0.rdata\[51\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput27 wdata[30] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_2
Xinput16 wdata[20] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_2
Xinput38 wdata[40] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_2
Xinput49 wdata[50] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_2
X_2270_ _0951_ _0952_ instance_0.mem\[3\]\[0\] VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__and3_1
XFILLER_0_87_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1985_ _0791_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3724_ net463 net70 _0850_ VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__mux2_1
X_3655_ _1789_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2606_ _0944_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__buf_8
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3586_ _1753_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__clkbuf_1
X_2537_ net175 _1089_ _1149_ _1150_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__o22a_1
X_2468_ instance_0.mem\[3\]\[51\] _0957_ _0941_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__a21o_1
X_4207_ clknet_leaf_34_clk _0433_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_2399_ net225 _1024_ _1047_ _1050_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__o22a_1
X_4138_ clknet_leaf_28_clk _0364_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[34\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4069_ clknet_leaf_22_clk _0295_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[37\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_26_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold608 instance_1.mem\[0\]\[51\] VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__dlygate4sd3_1
Xhold619 instance_1.mem\[1\]\[48\] VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3440_ net516 net10 _1670_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__mux2_1
X_3371_ net819 net54 _1633_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__mux2_1
X_2322_ instance_0.mem\[1\]\[11\] _0965_ _0993_ instance_0.mem\[0\]\[11\] _0960_ VGND
+ VGND VPWR VPWR _0994_ sky130_fd_sc_hd__a221o_1
XFILLER_0_85_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2253_ _0935_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_68_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2184_ _0854_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__buf_4
XFILLER_0_79_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1968_ _0782_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__clkbuf_1
X_3707_ _1816_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__clkbuf_1
X_1899_ _0746_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3638_ _1780_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3569_ _1744_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_39_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold5 instance_1.rdata\[40\] VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_65_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2940_ _1410_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__clkbuf_1
X_2871_ _1374_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold427 instance_0.mem\[3\]\[69\] VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__dlygate4sd3_1
X_4472_ clknet_leaf_49_clk _0698_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[8\] sky130_fd_sc_hd__dfxtp_1
Xhold405 instance_0.mem\[3\]\[4\] VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__dlygate4sd3_1
Xhold416 instance_1.rdata\[51\] VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__dlygate4sd3_1
Xhold438 instance_0.mem\[3\]\[43\] VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__dlygate4sd3_1
X_3423_ net613 net73 _1659_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__mux2_1
Xhold449 instance_1.mem\[0\]\[40\] VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__dlygate4sd3_1
X_3354_ net406 net45 _1622_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__mux2_1
X_2305_ net241 _0937_ _0977_ _0980_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__o22a_1
X_3285_ net635 net9 _1589_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2236_ _0926_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__clkbuf_1
X_2167_ _0890_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_36_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2098_ net3 net76 net1 net2 VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__or4_1
XFILLER_0_67_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3070_ _1479_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__clkbuf_1
X_2021_ _0812_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3972_ clknet_leaf_48_clk net346 VGND VGND VPWR VPWR instance_1.rdata\[12\] sky130_fd_sc_hd__dfxtp_1
X_2923_ net60 net725 _1401_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2854_ _1365_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__clkbuf_1
X_2785_ instance_1.mem\[0\]\[69\] instance_1.mem\[1\]\[69\] instance_1.mem\[2\]\[69\]
+ instance_1.mem\[3\]\[69\] _0944_ _1278_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__mux4_1
Xhold202 _0197_ VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold235 instance_0.mem\[3\]\[19\] VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__dlygate4sd3_1
Xhold224 _0205_ VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__dlygate4sd3_1
Xhold213 instance_1.rdata\[21\] VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__dlygate4sd3_1
X_4455_ clknet_leaf_55_clk _0681_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[63\] sky130_fd_sc_hd__dfxtp_1
Xhold246 instance_0.rdata\[14\] VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__dlygate4sd3_1
Xhold257 instance_1.mem\[1\]\[51\] VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__dlygate4sd3_1
Xhold268 instance_1.mem\[0\]\[46\] VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__dlygate4sd3_1
Xhold279 instance_1.mem\[0\]\[1\] VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__dlygate4sd3_1
X_4386_ clknet_leaf_2_clk _0612_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[66\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3406_ _0720_ _0801_ net1 net2 VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__and4bb_1
X_3337_ net581 net36 _1611_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_5_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3268_ net465 net70 _1578_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__mux2_1
X_3199_ net408 net44 _1541_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__mux2_1
X_2219_ _0917_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold791 instance_0.mem\[0\]\[4\] VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__dlygate4sd3_1
Xhold780 instance_0.mem\[2\]\[47\] VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_75_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_83_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2570_ instance_1.mem\[0\]\[6\] instance_1.mem\[1\]\[6\] instance_1.mem\[2\]\[6\]
+ instance_1.mem\[3\]\[6\] _1082_ _1130_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__mux4_1
XFILLER_0_50_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4240_ clknet_leaf_3_clk _0466_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_4171_ clknet_leaf_56_clk _0397_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_3122_ _1507_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3053_ _1470_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__clkbuf_1
X_2004_ net76 VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_18_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3955_ clknet_leaf_56_clk net188 VGND VGND VPWR VPWR instance_0.rdata\[67\] sky130_fd_sc_hd__dfxtp_1
X_2906_ net51 net687 _1390_ VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3886_ clknet_leaf_6_clk _0112_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[70\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_84_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2837_ _1356_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2768_ net410 _1315_ _1158_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2699_ instance_1.mem\[1\]\[41\] _1244_ _1086_ instance_1.mem\[0\]\[41\] _1263_ VGND
+ VGND VPWR VPWR _1269_ sky130_fd_sc_hd__a221o_1
X_4438_ clknet_leaf_20_clk _0664_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4369_ clknet_leaf_15_clk _0595_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[49\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_44_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3740_ _1833_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3671_ net51 net796 _1795_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2622_ net371 _1205_ _1212_ _1213_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__o22a_1
Xoutput104 net104 VGND VGND VPWR VPWR rdata[34] sky130_fd_sc_hd__clkbuf_4
Xoutput115 net115 VGND VGND VPWR VPWR rdata[44] sky130_fd_sc_hd__clkbuf_4
X_2553_ _1162_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput148 net148 VGND VGND VPWR VPWR rdata[9] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput137 net137 VGND VGND VPWR VPWR rdata[64] sky130_fd_sc_hd__clkbuf_4
Xoutput126 net126 VGND VGND VPWR VPWR rdata[54] sky130_fd_sc_hd__clkbuf_4
X_2484_ instance_0.mem\[0\]\[54\] _1039_ _1040_ instance_0.mem\[2\]\[54\] _1074_ VGND
+ VGND VPWR VPWR _1113_ sky130_fd_sc_hd__a221o_1
X_4223_ clknet_leaf_19_clk _0449_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[47\] sky130_fd_sc_hd__dfxtp_1
X_4154_ clknet_leaf_13_clk _0380_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_3105_ net425 net15 _1497_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4085_ clknet_leaf_11_clk _0311_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_3036_ net39 net751 _1460_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3938_ clknet_leaf_13_clk _0164_ VGND VGND VPWR VPWR instance_0.rdata\[50\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3869_ clknet_leaf_11_clk _0095_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_57_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput17 wdata[21] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_2
Xinput28 wdata[31] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_2
Xinput39 wdata[41] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_47_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1984_ instance_0.rdata\[62\] instance_1.rdata\[62\] _0788_ VGND VGND VPWR VPWR _0791_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3723_ _1824_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__clkbuf_1
X_3654_ net42 net777 _1784_ VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__mux2_1
X_2605_ _1201_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3585_ net6 net868 _1751_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__mux2_1
X_2536_ instance_0.mem\[1\]\[69\] _1122_ _1071_ instance_0.mem\[3\]\[69\] _1128_ VGND
+ VGND VPWR VPWR _1150_ sky130_fd_sc_hd__a221o_1
X_2467_ _1099_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4206_ clknet_leaf_23_clk _0432_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_2398_ instance_0.mem\[1\]\[31\] _1010_ _1048_ instance_0.mem\[0\]\[31\] _1049_ VGND
+ VGND VPWR VPWR _1050_ sky130_fd_sc_hd__a221o_1
X_4137_ clknet_leaf_30_clk _0363_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_54_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4068_ clknet_leaf_27_clk _0294_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_3019_ net30 net585 _1449_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_26_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold609 instance_1.mem\[2\]\[50\] VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3370_ _1638_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__clkbuf_1
X_2321_ _0962_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_0_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2252_ _0934_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_85_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2183_ _0898_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_34_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3706_ net69 net543 _1806_ VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_31_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1967_ instance_0.rdata\[54\] instance_1.rdata\[54\] _0777_ VGND VGND VPWR VPWR _0782_
+ sky130_fd_sc_hd__mux2_1
X_1898_ instance_0.rdata\[21\] instance_1.rdata\[21\] _0744_ VGND VGND VPWR VPWR _0746_
+ sky130_fd_sc_hd__mux2_1
X_3637_ net33 net952 _1773_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__mux2_1
X_3568_ net37 net758 _1740_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2519_ instance_0.mem\[0\]\[64\] _1042_ _1108_ instance_0.mem\[3\]\[64\] VGND VGND
+ VPWR VPWR _1138_ sky130_fd_sc_hd__a22o_1
XFILLER_0_59_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3499_ net586 net41 _1703_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_39_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold6 _0226_ VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_65_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2870_ net32 net664 _1368_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_10_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_8
Xhold406 instance_0.mem\[3\]\[33\] VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__dlygate4sd3_1
X_4471_ clknet_leaf_47_clk _0697_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xhold417 instance_1.mem\[1\]\[3\] VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold428 instance_1.mem\[1\]\[35\] VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__dlygate4sd3_1
X_3422_ _1666_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__clkbuf_1
Xhold439 instance_0.mem\[1\]\[13\] VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_29_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3353_ _1629_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__clkbuf_1
X_2304_ instance_0.mem\[0\]\[7\] _0947_ _0979_ instance_0.mem\[2\]\[7\] _0960_ VGND
+ VGND VPWR VPWR _0980_ sky130_fd_sc_hd__a221o_1
X_3284_ _1593_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__clkbuf_1
X_2235_ net64 net683 _0921_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_88_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2166_ net28 net830 _0888_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2097_ _0852_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2999_ _1442_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2020_ net576 net32 _0806_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3971_ clknet_leaf_49_clk net350 VGND VGND VPWR VPWR instance_1.rdata\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_33_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2922_ _1334_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__buf_4
XFILLER_0_31_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2853_ net23 net869 _1357_ VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__mux2_1
X_2784_ net291 _1295_ _1325_ _1326_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_41_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold203 instance_1.rdata\[17\] VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__dlygate4sd3_1
Xhold214 _0207_ VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__dlygate4sd3_1
Xhold225 instance_1.rdata\[32\] VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__dlygate4sd3_1
Xhold247 instance_1.mem\[2\]\[65\] VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__dlygate4sd3_1
X_4454_ clknet_leaf_2_clk _0680_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[62\] sky130_fd_sc_hd__dfxtp_1
Xhold236 instance_1.mem\[3\]\[51\] VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__dlygate4sd3_1
Xhold269 instance_0.rdata\[59\] VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__dlygate4sd3_1
Xhold258 instance_1.mem\[2\]\[47\] VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__dlygate4sd3_1
X_4385_ clknet_leaf_0_clk _0611_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[65\] sky130_fd_sc_hd__dfxtp_1
X_3405_ _1656_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__clkbuf_1
X_3336_ _1620_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_5_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3267_ _1584_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__clkbuf_1
X_3198_ _1547_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__clkbuf_1
X_2218_ net55 net844 _0910_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__mux2_1
X_2149_ net19 net902 _0877_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold770 instance_1.mem\[0\]\[43\] VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__dlygate4sd3_1
Xhold781 instance_1.mem\[0\]\[33\] VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold792 instance_0.mem\[3\]\[44\] VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_75_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4170_ clknet_leaf_1_clk _0396_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_3121_ net818 net75 _1497_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_2_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3052_ net47 net920 _1460_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2003_ _0800_ VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_18_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3954_ clknet_leaf_3_clk net210 VGND VGND VPWR VPWR instance_0.rdata\[66\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_85_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3885_ clknet_leaf_1_clk _0111_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_2905_ _1392_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__clkbuf_1
X_2836_ net14 net458 _1346_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2767_ instance_1.mem\[0\]\[63\] instance_1.mem\[1\]\[63\] instance_1.mem\[2\]\[63\]
+ instance_1.mem\[3\]\[63\] _0944_ _1278_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__mux4_1
X_2698_ instance_1.mem\[3\]\[41\] _0988_ _1248_ instance_1.mem\[2\]\[41\] VGND VGND
+ VPWR VPWR _1268_ sky130_fd_sc_hd__a22o_1
X_4437_ clknet_leaf_16_clk _0663_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[45\] sky130_fd_sc_hd__dfxtp_1
X_4368_ clknet_leaf_19_clk _0594_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_4299_ clknet_leaf_9_clk _0525_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_3319_ net494 net27 _1611_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_44_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3670_ _1797_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__clkbuf_1
X_2621_ instance_1.mem\[1\]\[19\] _1192_ _1154_ instance_1.mem\[0\]\[19\] _1193_ VGND
+ VGND VPWR VPWR _1213_ sky130_fd_sc_hd__a221o_1
XFILLER_0_35_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput105 net105 VGND VGND VPWR VPWR rdata[35] sky130_fd_sc_hd__clkbuf_4
Xoutput116 net116 VGND VGND VPWR VPWR rdata[45] sky130_fd_sc_hd__clkbuf_4
X_2552_ net504 _1161_ _1159_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__mux2_1
Xoutput138 net138 VGND VGND VPWR VPWR rdata[65] sky130_fd_sc_hd__clkbuf_4
Xoutput127 net127 VGND VGND VPWR VPWR rdata[55] sky130_fd_sc_hd__clkbuf_4
X_2483_ instance_0.mem\[1\]\[54\] _1111_ _1108_ instance_0.mem\[3\]\[54\] VGND VGND
+ VPWR VPWR _1112_ sky130_fd_sc_hd__a22o_1
X_4222_ clknet_leaf_20_clk _0448_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_4153_ clknet_leaf_15_clk _0379_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_4084_ clknet_leaf_15_clk _0310_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_3104_ _1498_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__clkbuf_1
X_3035_ _1461_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3937_ clknet_leaf_18_clk net208 VGND VGND VPWR VPWR instance_0.rdata\[49\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3868_ clknet_leaf_14_clk _0094_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_2819_ _1347_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3799_ clknet_leaf_11_clk _0025_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[55\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput18 wdata[22] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_2
Xinput29 wdata[32] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_20_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1983_ _0790_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_1
X_3722_ net660 net59 _0850_ VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__mux2_1
X_3653_ _1788_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__clkbuf_1
X_2604_ net548 _1200_ _1188_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3584_ _1752_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2535_ instance_0.mem\[0\]\[69\] _1042_ _1105_ instance_0.mem\[2\]\[69\] VGND VGND
+ VPWR VPWR _1149_ sky130_fd_sc_hd__a22o_1
X_2466_ net499 _1098_ _0935_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4205_ clknet_leaf_32_clk _0431_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_2397_ _0951_ _0952_ instance_0.mem\[3\]\[31\] VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__and3_1
X_4136_ clknet_leaf_31_clk _0362_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_4067_ clknet_leaf_27_clk _0293_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[35\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3018_ _1452_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2320_ instance_0.mem\[3\]\[11\] _0991_ _0986_ instance_0.mem\[2\]\[11\] VGND VGND
+ VPWR VPWR _0992_ sky130_fd_sc_hd__a22o_1
X_2251_ _0720_ _0801_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__and2b_1
X_2182_ net36 net434 _0888_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_23_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1966_ _0781_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_31_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3705_ _1815_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1897_ _0745_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__buf_1
X_3636_ _1779_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__clkbuf_1
X_3567_ _1743_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__clkbuf_1
X_2518_ _1135_ _1136_ _1137_ _0936_ net157 VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__o32a_1
X_3498_ _1706_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__clkbuf_1
X_2449_ _0962_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__buf_4
X_4119_ clknet_leaf_44_clk _0345_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold7 instance_0.rdata\[38\] VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4470_ clknet_leaf_55_clk _0696_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xhold407 instance_1.mem\[0\]\[23\] VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__dlygate4sd3_1
Xhold418 instance_1.mem\[2\]\[49\] VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__dlygate4sd3_1
X_3421_ net550 net70 _1659_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__mux2_1
Xhold429 instance_1.mem\[3\]\[32\] VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__dlygate4sd3_1
X_3352_ net381 net44 _1622_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2303_ _0978_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__buf_4
X_3283_ net628 net8 _1589_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__mux2_1
X_2234_ _0925_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_88_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2165_ _0889_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_36_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2096_ net413 net72 _0850_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2998_ net19 net784 _1438_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__mux2_1
X_1949_ _0772_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3619_ _1770_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_19_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3970_ clknet_leaf_46_clk _0196_ VGND VGND VPWR VPWR instance_1.rdata\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_33_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2921_ _1400_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_28_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2852_ _1364_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2783_ instance_1.mem\[0\]\[68\] _1252_ _1103_ instance_1.mem\[2\]\[68\] _1297_ VGND
+ VGND VPWR VPWR _1326_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_41_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold204 _0203_ VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__dlygate4sd3_1
X_4453_ clknet_leaf_2_clk _0679_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[61\] sky130_fd_sc_hd__dfxtp_1
Xhold215 instance_0.rdata\[24\] VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__dlygate4sd3_1
Xhold226 _0218_ VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__dlygate4sd3_1
Xhold259 instance_1.mem\[2\]\[0\] VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__dlygate4sd3_1
Xhold237 instance_1.mem\[3\]\[5\] VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__dlygate4sd3_1
X_3404_ net611 net72 _1577_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__mux2_1
Xhold248 instance_0.mem\[3\]\[32\] VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__dlygate4sd3_1
X_4384_ clknet_leaf_4_clk _0610_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_3335_ net478 net35 _1611_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3266_ net882 net59 _1578_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2217_ _0916_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__clkbuf_1
X_3197_ net483 net43 _1541_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__mux2_1
X_2148_ _0880_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__clkbuf_1
X_2079_ net452 net63 _0839_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_46_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold782 instance_0.mem\[0\]\[67\] VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__dlygate4sd3_1
Xhold771 instance_0.mem\[3\]\[68\] VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_55_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold760 instance_1.mem\[3\]\[59\] VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__dlygate4sd3_1
Xhold793 instance_0.mem\[0\]\[18\] VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_75_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_64_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_73_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3120_ _1506_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__clkbuf_1
X_3051_ _1469_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_85_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2002_ instance_0.rdata\[71\] instance_1.rdata\[71\] _0721_ VGND VGND VPWR VPWR _0800_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3953_ clknet_leaf_0_clk net186 VGND VGND VPWR VPWR instance_0.rdata\[65\] sky130_fd_sc_hd__dfxtp_1
X_3884_ clknet_leaf_4_clk _0110_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[68\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2904_ net50 net629 _1390_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__mux2_1
X_2835_ _1355_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2766_ _1314_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__clkbuf_1
X_2697_ _1265_ _1266_ _1267_ _1159_ net153 VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__o32a_1
X_4436_ clknet_leaf_23_clk _0662_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4367_ clknet_leaf_19_clk _0593_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3318_ _1577_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__buf_4
X_4298_ clknet_leaf_13_clk _0524_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_3249_ net682 net71 _1496_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold590 instance_0.mem\[2\]\[21\] VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_59_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2620_ instance_1.mem\[3\]\[19\] _1184_ _1197_ instance_1.mem\[2\]\[19\] VGND VGND
+ VPWR VPWR _1212_ sky130_fd_sc_hd__a22o_1
XFILLER_0_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput106 net106 VGND VGND VPWR VPWR rdata[36] sky130_fd_sc_hd__clkbuf_4
X_2551_ instance_1.mem\[0\]\[1\] instance_1.mem\[1\]\[1\] instance_1.mem\[2\]\[1\]
+ instance_1.mem\[3\]\[1\] _1082_ _1130_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__mux4_1
XFILLER_0_23_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput139 net139 VGND VGND VPWR VPWR rdata[66] sky130_fd_sc_hd__clkbuf_4
X_2482_ _0938_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__buf_4
Xoutput117 net117 VGND VGND VPWR VPWR rdata[46] sky130_fd_sc_hd__clkbuf_4
Xoutput128 net128 VGND VGND VPWR VPWR rdata[56] sky130_fd_sc_hd__clkbuf_4
X_4221_ clknet_leaf_14_clk _0447_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4152_ clknet_leaf_19_clk _0378_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_3103_ net444 net4 _1497_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4083_ clknet_leaf_9_clk _0309_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_3034_ net38 net697 _1460_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3936_ clknet_leaf_18_clk net280 VGND VGND VPWR VPWR instance_0.rdata\[48\] sky130_fd_sc_hd__dfxtp_1
X_3867_ clknet_leaf_8_clk _0093_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_2818_ net5 net759 _1346_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__mux2_1
X_3798_ clknet_leaf_10_clk _0024_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2749_ instance_1.mem\[3\]\[57\] _0988_ _0950_ instance_1.mem\[2\]\[57\] VGND VGND
+ VPWR VPWR _1303_ sky130_fd_sc_hd__a22o_1
X_4419_ clknet_leaf_32_clk _0645_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_57_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput19 wdata[23] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_20_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1982_ instance_0.rdata\[61\] instance_1.rdata\[61\] _0788_ VGND VGND VPWR VPWR _0790_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3721_ _1823_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__clkbuf_1
X_3652_ net41 net918 _1784_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3583_ net5 net624 _1751_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__mux2_1
X_2603_ instance_1.mem\[0\]\[14\] instance_1.mem\[1\]\[14\] instance_1.mem\[2\]\[14\]
+ instance_1.mem\[3\]\[14\] _1082_ _1130_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__mux4_1
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2534_ net265 _1089_ _1147_ _1148_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__o22a_1
X_2465_ instance_0.mem\[0\]\[50\] instance_0.mem\[1\]\[50\] instance_0.mem\[2\]\[50\]
+ instance_0.mem\[3\]\[50\] _1082_ _0974_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__mux4_1
X_2396_ _0962_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__buf_4
X_4204_ clknet_leaf_35_clk _0430_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_4135_ clknet_leaf_22_clk _0361_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4066_ clknet_leaf_28_clk _0292_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3017_ net29 net761 _1449_ VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3919_ clknet_leaf_34_clk net226 VGND VGND VPWR VPWR instance_0.rdata\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_61_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2250_ _0933_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__clkbuf_1
X_2181_ _0897_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1965_ instance_0.rdata\[53\] instance_1.rdata\[53\] _0777_ VGND VGND VPWR VPWR _0781_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3704_ net68 net836 _1806_ VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_31_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1896_ instance_0.rdata\[20\] instance_1.rdata\[20\] _0744_ VGND VGND VPWR VPWR _0745_
+ sky130_fd_sc_hd__mux2_1
X_3635_ net32 net949 _1773_ VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__mux2_1
X_3566_ net26 net959 _1740_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__mux2_1
X_3497_ net892 net40 _1703_ VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__mux2_1
X_2517_ instance_0.mem\[3\]\[63\] _0988_ _0960_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__a21o_1
X_2448_ instance_0.mem\[2\]\[46\] _0978_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__and2_1
X_2379_ instance_0.mem\[3\]\[27\] _1016_ _1008_ instance_0.mem\[2\]\[27\] VGND VGND
+ VPWR VPWR _1035_ sky130_fd_sc_hd__a22o_1
X_4118_ clknet_leaf_45_clk _0344_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_67_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4049_ clknet_leaf_41_clk _0275_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold8 _0152_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold408 instance_1.mem\[2\]\[57\] VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__dlygate4sd3_1
X_3420_ _1665_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold419 instance_1.rdata\[47\] VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__dlygate4sd3_1
X_3351_ _1628_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2302_ _0949_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__buf_4
X_3282_ _1592_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2233_ net63 net956 _0921_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_88_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2164_ net27 net732 _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_64_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2095_ _0851_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2997_ _1441_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__clkbuf_1
X_1948_ instance_0.rdata\[45\] instance_1.rdata\[45\] _0766_ VGND VGND VPWR VPWR _0772_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1879_ instance_0.rdata\[12\] instance_1.rdata\[12\] _0733_ VGND VGND VPWR VPWR _0736_
+ sky130_fd_sc_hd__mux2_1
X_3618_ net23 net974 _1762_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__mux2_1
X_3549_ net608 net67 _1725_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_70_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_78_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2920_ net58 net446 _1390_ VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2851_ net22 net966 _1357_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__mux2_1
X_2782_ instance_1.mem\[1\]\[68\] _0965_ _0991_ instance_1.mem\[3\]\[68\] VGND VGND
+ VPWR VPWR _1325_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_41_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4452_ clknet_leaf_57_clk _0678_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[60\] sky130_fd_sc_hd__dfxtp_1
Xhold205 instance_0.rdata\[26\] VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__dlygate4sd3_1
Xhold216 _0138_ VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__dlygate4sd3_1
Xhold238 instance_1.mem\[3\]\[20\] VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__dlygate4sd3_1
X_3403_ _1655_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__clkbuf_1
Xhold227 instance_1.mem\[1\]\[40\] VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__dlygate4sd3_1
Xhold249 instance_1.rdata\[46\] VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4383_ clknet_leaf_52_clk _0609_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[63\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3334_ _1619_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__clkbuf_1
X_3265_ _1583_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2216_ net54 net716 _0910_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__mux2_1
X_3196_ _1546_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_49_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2147_ net18 net958 _0877_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__mux2_1
X_2078_ _0842_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold750 instance_1.mem\[2\]\[44\] VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__dlygate4sd3_1
Xhold772 instance_0.mem\[2\]\[49\] VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__dlygate4sd3_1
Xhold761 instance_0.mem\[2\]\[58\] VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__dlygate4sd3_1
Xhold783 instance_0.mem\[2\]\[0\] VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__dlygate4sd3_1
Xhold794 instance_0.mem\[1\]\[17\] VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_4_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3050_ net46 net764 _1460_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__mux2_1
X_2001_ _0799_ VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_85_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3952_ clknet_leaf_4_clk net294 VGND VGND VPWR VPWR instance_0.rdata\[64\] sky130_fd_sc_hd__dfxtp_1
X_2903_ _1391_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__clkbuf_1
X_3883_ clknet_leaf_1_clk _0109_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_2834_ net13 net924 _1346_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__mux2_1
X_2765_ net530 _1313_ _1158_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2696_ instance_1.mem\[0\]\[40\] _0962_ _1103_ instance_1.mem\[2\]\[40\] VGND VGND
+ VPWR VPWR _1267_ sky130_fd_sc_hd__a22o_1
X_4435_ clknet_leaf_17_clk _0661_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[43\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4366_ clknet_leaf_6_clk _0592_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3317_ _1610_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__clkbuf_1
X_4297_ clknet_leaf_18_clk _0523_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_3248_ _1573_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3179_ _1537_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold580 instance_0.mem\[2\]\[10\] VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold591 instance_1.mem\[1\]\[55\] VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput107 net107 VGND VGND VPWR VPWR rdata[37] sky130_fd_sc_hd__clkbuf_4
X_2550_ _1160_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput118 net118 VGND VGND VPWR VPWR rdata[47] sky130_fd_sc_hd__clkbuf_4
Xoutput129 net129 VGND VGND VPWR VPWR rdata[57] sky130_fd_sc_hd__clkbuf_4
X_2481_ net325 _1092_ _1109_ _1110_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__o22a_1
X_4220_ clknet_leaf_23_clk _0446_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4151_ clknet_leaf_19_clk _0377_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[47\] sky130_fd_sc_hd__dfxtp_1
X_4082_ clknet_leaf_13_clk _0308_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_3102_ _1496_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__buf_4
X_3033_ _1415_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__buf_4
XFILLER_0_58_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3935_ clknet_leaf_19_clk net222 VGND VGND VPWR VPWR instance_0.rdata\[47\] sky130_fd_sc_hd__dfxtp_1
X_3866_ clknet_leaf_13_clk _0092_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[50\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_82_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2817_ _1334_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__buf_4
X_3797_ clknet_leaf_11_clk _0023_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_2748_ net317 _1295_ _1301_ _1302_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__o22a_1
X_2679_ instance_1.mem\[1\]\[36\] _1224_ _1177_ instance_1.mem\[3\]\[36\] VGND VGND
+ VPWR VPWR _1254_ sky130_fd_sc_hd__a22o_1
X_4418_ clknet_leaf_32_clk _0644_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_4349_ clknet_leaf_34_clk _0575_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[29\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_57_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1981_ _0789_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__clkbuf_1
X_3720_ net593 net48 _0850_ VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_40_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_40_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_55_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3651_ _1787_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__clkbuf_1
X_2602_ net283 _1163_ _1198_ _1199_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__o22a_1
X_3582_ _1739_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__buf_4
X_2533_ instance_0.mem\[0\]\[68\] _1145_ _1127_ instance_0.mem\[2\]\[68\] _1128_ VGND
+ VGND VPWR VPWR _1148_ sky130_fd_sc_hd__a221o_1
X_2464_ net207 _1092_ _1096_ _1097_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__o22a_1
X_4203_ clknet_leaf_32_clk _0429_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_2395_ instance_0.mem\[2\]\[31\] _0986_ _0942_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__a21o_1
X_4134_ clknet_leaf_24_clk _0360_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_4065_ clknet_leaf_30_clk _0291_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3016_ _1451_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3918_ clknet_leaf_23_clk _0144_ VGND VGND VPWR VPWR instance_0.rdata\[30\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_31_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_31_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_61_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3849_ clknet_leaf_28_clk _0075_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_89_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_22_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_22_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_52_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2180_ net35 net598 _0888_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1964_ _0780_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_13_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3703_ _1814_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3634_ _1778_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_31_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1895_ _0721_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__buf_4
X_3565_ _1742_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__clkbuf_1
X_3496_ _1705_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__clkbuf_1
X_2516_ instance_0.mem\[1\]\[63\] _0938_ _1086_ instance_0.mem\[0\]\[63\] VGND VGND
+ VPWR VPWR _1136_ sky130_fd_sc_hd__a22o_1
X_2447_ _1084_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2378_ net353 _1024_ _1033_ _1034_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__o22a_1
X_4117_ clknet_leaf_44_clk _0343_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_67_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4048_ clknet_leaf_45_clk _0274_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold9 instance_0.rdata\[63\] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_73_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_4_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_496 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold409 instance_0.mem\[2\]\[55\] VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3350_ net568 net43 _1622_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2301_ instance_0.mem\[1\]\[7\] _0939_ _0958_ instance_0.mem\[3\]\[7\] VGND VGND
+ VPWR VPWR _0977_ sky130_fd_sc_hd__a22o_1
X_3281_ net536 net7 _1589_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__mux2_1
X_2232_ _0924_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_2_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_2_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_88_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2163_ _0854_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_64_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2094_ net749 net71 _0850_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2996_ net18 net899 _1438_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__mux2_1
X_1947_ _0771_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1878_ _0735_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__buf_1
XFILLER_0_31_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3617_ _1769_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__clkbuf_1
X_3548_ _1732_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__clkbuf_1
X_3479_ _1696_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_78_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2850_ _1363_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2781_ _1324_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_41_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold206 _0140_ VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__dlygate4sd3_1
Xhold217 instance_1.rdata\[26\] VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__dlygate4sd3_1
X_4451_ clknet_leaf_11_clk _0677_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[59\] sky130_fd_sc_hd__dfxtp_1
Xhold239 instance_0.mem\[3\]\[45\] VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__dlygate4sd3_1
Xhold228 instance_1.mem\[1\]\[60\] VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__dlygate4sd3_1
X_3402_ net792 net71 _1577_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__mux2_1
X_4382_ clknet_leaf_1_clk _0608_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_3333_ net723 net34 _1611_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3264_ net441 net48 _1578_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2215_ _0915_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__clkbuf_1
X_3195_ net706 net42 _1541_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__mux2_1
X_2146_ _0879_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_49_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2077_ net481 net62 _0839_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2979_ net9 net591 _1427_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold740 instance_0.mem\[0\]\[14\] VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__dlygate4sd3_1
Xhold751 instance_0.mem\[2\]\[22\] VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__dlygate4sd3_1
Xhold762 instance_1.mem\[0\]\[22\] VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__dlygate4sd3_1
Xhold773 instance_0.mem\[2\]\[26\] VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__dlygate4sd3_1
Xhold795 instance_0.mem\[1\]\[23\] VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__dlygate4sd3_1
Xhold784 instance_0.mem\[2\]\[29\] VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_4_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2000_ instance_0.rdata\[70\] instance_1.rdata\[70\] _0721_ VGND VGND VPWR VPWR _0799_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3951_ clknet_leaf_52_clk net158 VGND VGND VPWR VPWR instance_0.rdata\[63\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2902_ net49 net542 _1390_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3882_ clknet_leaf_2_clk _0108_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[66\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2833_ _1354_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__clkbuf_1
X_2764_ instance_1.mem\[0\]\[62\] instance_1.mem\[1\]\[62\] instance_1.mem\[2\]\[62\]
+ instance_1.mem\[3\]\[62\] _1202_ _1278_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__mux4_1
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2695_ instance_1.mem\[1\]\[40\] _0938_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__and2_1
X_4434_ clknet_leaf_17_clk _0660_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[42\] sky130_fd_sc_hd__dfxtp_1
X_4365_ clknet_leaf_14_clk _0591_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3316_ net923 net25 _1600_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__mux2_1
X_4296_ clknet_leaf_21_clk _0522_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_3247_ net671 net69 _1563_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__mux2_1
X_3178_ net663 net33 _1530_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2129_ _0870_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_80_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold570 instance_1.mem\[1\]\[50\] VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__dlygate4sd3_1
Xhold581 instance_1.mem\[2\]\[8\] VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__dlygate4sd3_1
Xhold592 instance_0.mem\[1\]\[56\] VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput108 net108 VGND VGND VPWR VPWR rdata[38] sky130_fd_sc_hd__clkbuf_4
Xoutput119 net119 VGND VGND VPWR VPWR rdata[48] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2480_ instance_0.mem\[0\]\[53\] _1039_ _1040_ instance_0.mem\[2\]\[53\] _1074_ VGND
+ VGND VPWR VPWR _1110_ sky130_fd_sc_hd__a221o_1
XFILLER_0_10_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4150_ clknet_leaf_7_clk _0376_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[46\] sky130_fd_sc_hd__dfxtp_1
Xoutput90 net90 VGND VGND VPWR VPWR rdata[21] sky130_fd_sc_hd__clkbuf_4
X_3101_ _1495_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__clkbuf_4
X_4081_ clknet_leaf_15_clk _0307_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_3032_ _1459_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3934_ clknet_leaf_6_clk net152 VGND VGND VPWR VPWR instance_0.rdata\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_85_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3865_ clknet_leaf_15_clk _0091_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_2816_ _1345_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3796_ clknet_leaf_12_clk _0022_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[52\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2747_ instance_1.mem\[1\]\[56\] _1102_ _0957_ instance_1.mem\[3\]\[56\] _1297_ VGND
+ VGND VPWR VPWR _1302_ sky130_fd_sc_hd__a221o_1
X_2678_ net193 _1232_ _1251_ _1253_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__o22a_1
XFILLER_0_14_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4417_ clknet_leaf_39_clk _0643_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4348_ clknet_leaf_34_clk _0574_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_4279_ clknet_leaf_34_clk _0505_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[31\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_57_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1980_ instance_0.rdata\[60\] instance_1.rdata\[60\] _0788_ VGND VGND VPWR VPWR _0789_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3650_ net40 net927 _1784_ VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__mux2_1
X_2601_ instance_1.mem\[1\]\[13\] _1192_ _1071_ instance_1.mem\[3\]\[13\] _1193_ VGND
+ VGND VPWR VPWR _1199_ sky130_fd_sc_hd__a221o_1
X_3581_ _1750_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2532_ instance_0.mem\[1\]\[68\] _1111_ _1108_ instance_0.mem\[3\]\[68\] VGND VGND
+ VPWR VPWR _1147_ sky130_fd_sc_hd__a22o_1
X_2463_ instance_0.mem\[0\]\[49\] _1039_ _1040_ instance_0.mem\[2\]\[49\] _1074_ VGND
+ VGND VPWR VPWR _1097_ sky130_fd_sc_hd__a221o_1
X_4202_ clknet_leaf_32_clk _0428_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_2394_ _1046_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__clkbuf_1
X_4133_ clknet_leaf_34_clk _0359_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4064_ clknet_leaf_31_clk _0290_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_3015_ net28 net695 _1449_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3917_ clknet_leaf_31_clk net310 VGND VGND VPWR VPWR instance_0.rdata\[29\] sky130_fd_sc_hd__dfxtp_1
X_3848_ clknet_leaf_31_clk _0074_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_3779_ clknet_leaf_26_clk _0005_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1963_ instance_0.rdata\[52\] instance_1.rdata\[52\] _0777_ VGND VGND VPWR VPWR _0780_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3702_ net67 net562 _1806_ VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__mux2_1
X_1894_ _0743_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3633_ net31 net633 _1773_ VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_31_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3564_ net15 net427 _1740_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3495_ net799 net39 _1703_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2515_ instance_0.mem\[2\]\[63\] _0978_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__and2_1
X_2446_ net414 _1083_ _0935_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4116_ clknet_leaf_42_clk _0342_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_2377_ instance_0.mem\[0\]\[26\] _0947_ _0979_ instance_0.mem\[2\]\[26\] _0999_ VGND
+ VGND VPWR VPWR _1034_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_67_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4047_ clknet_leaf_44_clk _0273_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2300_ _0976_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3280_ _1591_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__clkbuf_1
X_2231_ net62 net965 _0921_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__mux2_1
X_2162_ _0887_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_88_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2093_ _0805_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_64_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2995_ _1440_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1946_ instance_0.rdata\[44\] instance_1.rdata\[44\] _0766_ VGND VGND VPWR VPWR _0771_
+ sky130_fd_sc_hd__mux2_1
X_1877_ instance_0.rdata\[11\] instance_1.rdata\[11\] _0733_ VGND VGND VPWR VPWR _0735_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3616_ net22 net975 _1762_ VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__mux2_1
X_3547_ net791 net66 _1725_ VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3478_ net554 net30 _1692_ VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__mux2_1
X_2429_ instance_0.mem\[1\]\[40\] _1058_ _1071_ instance_0.mem\[3\]\[40\] _1036_ VGND
+ VGND VPWR VPWR _1072_ sky130_fd_sc_hd__a221o_1
XFILLER_0_66_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2780_ net453 _1323_ _1158_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold207 instance_1.rdata\[25\] VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__dlygate4sd3_1
X_4450_ clknet_leaf_6_clk _0676_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[58\] sky130_fd_sc_hd__dfxtp_1
Xhold229 instance_1.mem\[1\]\[65\] VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__dlygate4sd3_1
X_3401_ _1654_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__clkbuf_1
X_4381_ clknet_leaf_2_clk _0607_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold218 _0212_ VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__dlygate4sd3_1
X_3332_ _1618_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3263_ _1582_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__clkbuf_1
X_3194_ _1545_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__clkbuf_1
X_2214_ net53 net544 _0910_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2145_ net17 net773 _0877_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_49_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2076_ _0841_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_3_5__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_2978_ _1431_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__clkbuf_1
X_1929_ instance_0.rdata\[36\] instance_1.rdata\[36\] _0755_ VGND VGND VPWR VPWR _0762_
+ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_15_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold730 instance_0.mem\[2\]\[4\] VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__dlygate4sd3_1
Xhold752 instance_0.mem\[0\]\[60\] VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__dlygate4sd3_1
Xhold763 instance_0.mem\[0\]\[69\] VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__dlygate4sd3_1
Xhold741 instance_0.mem\[0\]\[47\] VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__dlygate4sd3_1
Xhold774 instance_0.mem\[0\]\[13\] VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__dlygate4sd3_1
Xhold796 instance_0.mem\[1\]\[63\] VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__dlygate4sd3_1
Xhold785 instance_1.mem\[0\]\[9\] VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_4_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_33_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_42_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold90 _0156_ VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3950_ clknet_leaf_4_clk net360 VGND VGND VPWR VPWR instance_0.rdata\[62\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2901_ _1334_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__buf_4
X_3881_ clknet_leaf_1_clk _0107_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[65\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_51_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2832_ net12 net942 _1346_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__mux2_1
X_2763_ net231 _1295_ _1311_ _1312_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__o22a_1
XFILLER_0_13_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2694_ instance_1.mem\[3\]\[40\] _0957_ _1165_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__a21o_1
X_4433_ clknet_leaf_16_clk _0659_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[41\] sky130_fd_sc_hd__dfxtp_1
X_4364_ clknet_leaf_18_clk _0590_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3315_ _1609_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_60_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4295_ clknet_leaf_19_clk _0521_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3246_ _1572_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__clkbuf_1
X_3177_ _1536_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_1_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2128_ net8 net922 _0866_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__mux2_1
X_2059_ _0832_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold571 instance_0.mem\[0\]\[50\] VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__dlygate4sd3_1
Xhold560 instance_0.mem\[3\]\[1\] VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__dlygate4sd3_1
Xhold582 instance_1.mem\[1\]\[12\] VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__dlygate4sd3_1
Xhold593 instance_1.mem\[0\]\[4\] VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_59_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput109 net109 VGND VGND VPWR VPWR rdata[39] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput80 net80 VGND VGND VPWR VPWR rdata[12] sky130_fd_sc_hd__clkbuf_4
Xoutput91 net91 VGND VGND VPWR VPWR rdata[22] sky130_fd_sc_hd__clkbuf_4
X_3100_ _0801_ _0956_ _0720_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__and3b_1
X_4080_ clknet_leaf_18_clk _0306_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_3031_ net36 net424 _1449_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3933_ clknet_leaf_16_clk _0159_ VGND VGND VPWR VPWR instance_0.rdata\[45\] sky130_fd_sc_hd__dfxtp_1
X_3864_ clknet_leaf_18_clk _0090_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[48\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2815_ net75 net787 _1335_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__mux2_1
X_3795_ clknet_leaf_9_clk _0021_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[51\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2746_ instance_1.mem\[0\]\[56\] _0993_ _0950_ instance_1.mem\[2\]\[56\] VGND VGND
+ VPWR VPWR _1301_ sky130_fd_sc_hd__a22o_1
X_2677_ instance_1.mem\[0\]\[35\] _1252_ _1181_ instance_1.mem\[2\]\[35\] _1230_ VGND
+ VGND VPWR VPWR _1253_ sky130_fd_sc_hd__a221o_1
XFILLER_0_5_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4416_ clknet_leaf_35_clk _0642_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_68_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4347_ clknet_leaf_33_clk _0573_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_4278_ clknet_leaf_22_clk _0504_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_3229_ net421 net60 _1563_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_57_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold390 instance_0.mem\[3\]\[14\] VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2600_ instance_1.mem\[0\]\[13\] _1190_ _1197_ instance_1.mem\[2\]\[13\] VGND VGND
+ VPWR VPWR _1198_ sky130_fd_sc_hd__a22o_1
X_3580_ net75 net933 _1740_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__mux2_1
X_2531_ net187 _1089_ _1144_ _1146_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__o22a_1
XFILLER_0_11_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2462_ instance_0.mem\[1\]\[49\] _1021_ _1030_ instance_0.mem\[3\]\[49\] VGND VGND
+ VPWR VPWR _1096_ sky130_fd_sc_hd__a22o_1
X_4201_ clknet_leaf_40_clk _0427_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_2393_ net457 _1045_ _0935_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__mux2_1
X_4132_ clknet_leaf_35_clk _0358_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_4063_ clknet_leaf_22_clk _0289_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_3014_ _1450_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_54_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3916_ clknet_leaf_33_clk net250 VGND VGND VPWR VPWR instance_0.rdata\[28\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_62_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3847_ clknet_leaf_22_clk _0073_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_3778_ clknet_leaf_30_clk _0004_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[34\] sky130_fd_sc_hd__dfxtp_1
X_2729_ instance_1.mem\[0\]\[51\] instance_1.mem\[1\]\[51\] instance_1.mem\[2\]\[51\]
+ instance_1.mem\[3\]\[51\] _1202_ _1278_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1962_ _0779_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1893_ instance_0.rdata\[19\] instance_1.rdata\[19\] _0733_ VGND VGND VPWR VPWR _0743_
+ sky130_fd_sc_hd__mux2_1
X_3701_ _1813_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3632_ _1777_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3563_ _1741_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2514_ net359 _1092_ _1133_ _1134_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__o22a_1
X_3494_ _1704_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__clkbuf_1
X_2445_ instance_0.mem\[0\]\[45\] instance_0.mem\[1\]\[45\] instance_0.mem\[2\]\[45\]
+ instance_0.mem\[3\]\[45\] _1082_ _0974_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__mux4_1
XFILLER_0_11_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4115_ clknet_leaf_49_clk _0341_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_2376_ instance_0.mem\[1\]\[26\] _1021_ _1030_ instance_0.mem\[3\]\[26\] VGND VGND
+ VPWR VPWR _1033_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_67_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4046_ clknet_leaf_45_clk _0272_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_89_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2230_ _0923_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__clkbuf_1
X_2161_ net25 net917 _0877_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__mux2_1
X_2092_ _0849_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_64_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_72_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2994_ net17 net738 _1438_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__mux2_1
X_1945_ _0770_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1876_ _0734_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3615_ _1768_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3546_ _1731_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__clkbuf_1
X_3477_ _1695_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__clkbuf_1
X_2428_ _0956_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__clkbuf_8
X_2359_ net173 _0990_ _1019_ _1020_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__o22a_1
X_4029_ clknet_leaf_0_clk _0255_ VGND VGND VPWR VPWR instance_1.rdata\[69\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold208 _0211_ VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__dlygate4sd3_1
X_3400_ net388 net69 _1644_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__mux2_1
X_4380_ clknet_leaf_0_clk _0606_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[60\] sky130_fd_sc_hd__dfxtp_1
Xhold219 instance_1.rdata\[37\] VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__dlygate4sd3_1
X_3331_ net600 net33 _1611_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__mux2_1
X_3262_ net781 net37 _1578_ VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__mux2_1
X_3193_ net642 net41 _1541_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2213_ _0914_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__clkbuf_1
X_2144_ _0878_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_22_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2075_ net525 net61 _0839_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2977_ net8 net702 _1427_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1928_ _0761_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1859_ _0725_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__buf_1
Xhold720 instance_1.mem\[0\]\[11\] VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__dlygate4sd3_1
Xhold753 instance_1.mem\[0\]\[17\] VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__dlygate4sd3_1
Xhold742 instance_1.mem\[3\]\[26\] VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__dlygate4sd3_1
Xhold731 instance_0.mem\[2\]\[56\] VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__dlygate4sd3_1
Xhold764 instance_1.mem\[0\]\[57\] VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__dlygate4sd3_1
Xhold786 instance_0.mem\[0\]\[11\] VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__dlygate4sd3_1
Xhold797 instance_1.mem\[0\]\[58\] VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__dlygate4sd3_1
Xhold775 instance_1.mem\[2\]\[29\] VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__dlygate4sd3_1
X_3529_ _1722_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_4_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold91 instance_1.rdata\[52\] VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__dlygate4sd3_1
Xhold80 _0222_ VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2900_ _1389_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_18_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3880_ clknet_leaf_4_clk _0106_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_2831_ _1353_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2762_ instance_1.mem\[0\]\[61\] _1252_ _1103_ instance_1.mem\[2\]\[61\] _1297_ VGND
+ VGND VPWR VPWR _1312_ sky130_fd_sc_hd__a221o_1
X_2693_ net171 _1261_ _1262_ _1264_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__o22a_1
X_4432_ clknet_leaf_20_clk _0658_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_4363_ clknet_leaf_17_clk _0589_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[43\] sky130_fd_sc_hd__dfxtp_1
X_3314_ net507 net24 _1600_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__mux2_1
X_4294_ clknet_leaf_20_clk _0520_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_3245_ net812 net68 _1563_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__mux2_1
X_3176_ net590 net32 _1530_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2127_ _0869_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2058_ net540 net52 _0828_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold550 instance_1.mem\[2\]\[58\] VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__dlygate4sd3_1
Xhold561 instance_0.mem\[1\]\[70\] VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__dlygate4sd3_1
Xhold572 instance_1.mem\[0\]\[56\] VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__dlygate4sd3_1
Xhold583 instance_1.mem\[2\]\[19\] VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__dlygate4sd3_1
Xhold594 instance_0.mem\[0\]\[2\] VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_52_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_52_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_12_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput81 net81 VGND VGND VPWR VPWR rdata[13] sky130_fd_sc_hd__clkbuf_4
Xoutput92 net92 VGND VGND VPWR VPWR rdata[23] sky130_fd_sc_hd__clkbuf_4
X_3030_ _1458_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__clkbuf_1
X_3932_ clknet_leaf_17_clk net334 VGND VGND VPWR VPWR instance_0.rdata\[44\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_43_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_43_clk sky130_fd_sc_hd__clkbuf_8
X_3863_ clknet_leaf_19_clk _0089_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2814_ _1344_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__clkbuf_1
X_3794_ clknet_leaf_13_clk _0020_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_2745_ net243 _1295_ _1299_ _1300_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__o22a_1
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2676_ _0946_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_78_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4415_ clknet_leaf_36_clk _0641_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4346_ clknet_leaf_33_clk _0572_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_4277_ clknet_leaf_32_clk _0503_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_3228_ _1496_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__buf_4
X_3159_ net599 net23 _1519_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_57_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_34_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_34_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_76_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold380 instance_1.mem\[1\]\[38\] VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold391 instance_0.mem\[3\]\[13\] VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_25_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_25_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_23_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2530_ instance_0.mem\[0\]\[67\] _1145_ _1071_ instance_0.mem\[3\]\[67\] _1128_ VGND
+ VGND VPWR VPWR _1146_ sky130_fd_sc_hd__a221o_1
X_2461_ net279 _1092_ _1093_ _1095_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__o22a_1
XFILLER_0_48_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4200_ clknet_leaf_21_clk _0426_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_2392_ instance_0.mem\[0\]\[30\] instance_0.mem\[1\]\[30\] instance_0.mem\[2\]\[30\]
+ instance_0.mem\[3\]\[30\] _0973_ _0974_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__mux4_1
XFILLER_0_48_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4131_ clknet_leaf_33_clk _0357_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_4062_ clknet_leaf_23_clk _0288_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_3013_ net27 net445 _1449_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_16_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_80_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3915_ clknet_leaf_33_clk net348 VGND VGND VPWR VPWR instance_0.rdata\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_80_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3846_ clknet_leaf_23_clk _0072_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3777_ clknet_leaf_30_clk _0003_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_54_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2728_ net341 _1261_ _1287_ _1288_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__o22a_1
X_2659_ instance_1.mem\[0\]\[30\] _1145_ _1181_ instance_1.mem\[2\]\[30\] _1230_ VGND
+ VGND VPWR VPWR _1240_ sky130_fd_sc_hd__a221o_1
X_4329_ clknet_leaf_51_clk _0555_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_84_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3700_ net66 net871 _1806_ VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__mux2_1
X_1961_ instance_0.rdata\[51\] instance_1.rdata\[51\] _0777_ VGND VGND VPWR VPWR _0779_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1892_ _0742_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3631_ net30 net929 _1773_ VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__mux2_1
X_3562_ net4 net625 _1740_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2513_ instance_0.mem\[1\]\[62\] _1122_ _1048_ instance_0.mem\[0\]\[62\] _1128_ VGND
+ VGND VPWR VPWR _1134_ sky130_fd_sc_hd__a221o_1
X_3493_ net602 net38 _1703_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__mux2_1
X_2444_ _0944_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_leaf_5_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_8
X_2375_ net211 _1024_ _1031_ _1032_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__o22a_1
X_4114_ clknet_leaf_45_clk _0340_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_67_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4045_ clknet_leaf_43_clk _0271_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3829_ clknet_leaf_42_clk _0055_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2160_ _0886_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_88_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2091_ net450 net69 _0839_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2993_ _1439_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1944_ instance_0.rdata\[43\] instance_1.rdata\[43\] _0766_ VGND VGND VPWR VPWR _0770_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1875_ instance_0.rdata\[10\] instance_1.rdata\[10\] _0733_ VGND VGND VPWR VPWR _0734_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3614_ net21 net788 _1762_ VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3545_ net794 net65 _1725_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__mux2_1
X_3476_ net396 net29 _1692_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2427_ instance_0.mem\[0\]\[40\] _1042_ _1008_ instance_0.mem\[2\]\[40\] VGND VGND
+ VPWR VPWR _1070_ sky130_fd_sc_hd__a22o_1
XFILLER_0_86_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2358_ instance_0.mem\[0\]\[21\] _0947_ _0979_ instance_0.mem\[2\]\[21\] _0999_ VGND
+ VGND VPWR VPWR _1020_ sky130_fd_sc_hd__a221o_1
X_2289_ net197 _0937_ _0967_ _0968_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__o22a_1
XFILLER_0_79_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4028_ clknet_leaf_5_clk net292 VGND VGND VPWR VPWR instance_1.rdata\[68\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_8_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_41_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold209 instance_1.rdata\[9\] VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__dlygate4sd3_1
X_3330_ _1617_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3261_ _1581_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__clkbuf_1
X_3192_ _1544_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__clkbuf_1
X_2212_ net52 net802 _0910_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__mux2_1
X_2143_ net16 net834 _0877_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__mux2_1
X_2074_ _0840_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2976_ _1430_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1927_ instance_0.rdata\[35\] instance_1.rdata\[35\] _0755_ VGND VGND VPWR VPWR _0761_
+ sky130_fd_sc_hd__mux2_1
X_1858_ instance_0.rdata\[2\] instance_1.rdata\[2\] _0722_ VGND VGND VPWR VPWR _0725_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold721 instance_0.mem\[1\]\[27\] VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__dlygate4sd3_1
Xhold710 instance_1.mem\[0\]\[37\] VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__dlygate4sd3_1
Xhold732 instance_0.mem\[0\]\[3\] VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__dlygate4sd3_1
Xhold743 instance_0.rdata\[19\] VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__dlygate4sd3_1
Xhold754 instance_0.mem\[0\]\[23\] VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__dlygate4sd3_1
Xhold765 instance_0.mem\[2\]\[11\] VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__dlygate4sd3_1
Xhold776 instance_0.mem\[1\]\[18\] VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__dlygate4sd3_1
Xhold787 instance_1.mem\[0\]\[61\] VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__dlygate4sd3_1
X_3528_ net588 net56 _1714_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__mux2_1
X_3459_ net561 net20 _1681_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__mux2_1
Xhold798 instance_0.mem\[0\]\[28\] VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_4_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold92 _0238_ VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__dlygate4sd3_1
Xhold70 _0190_ VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dlygate4sd3_1
Xhold81 instance_0.rdata\[40\] VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2830_ net11 net963 _1346_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2761_ instance_1.mem\[1\]\[61\] _1224_ _0991_ instance_1.mem\[3\]\[61\] VGND VGND
+ VPWR VPWR _1311_ sky130_fd_sc_hd__a22o_1
XFILLER_0_53_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2692_ instance_1.mem\[1\]\[39\] _1244_ _1086_ instance_1.mem\[0\]\[39\] _1263_ VGND
+ VGND VPWR VPWR _1264_ sky130_fd_sc_hd__a221o_1
XFILLER_0_26_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4431_ clknet_leaf_25_clk _0657_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_1 _0988_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4362_ clknet_leaf_17_clk _0588_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4293_ clknet_leaf_14_clk _0519_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[45\] sky130_fd_sc_hd__dfxtp_1
X_3313_ _1608_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__clkbuf_1
X_3244_ _1571_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__clkbuf_1
X_3175_ _1535_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2126_ net7 net832 _0866_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__mux2_1
X_2057_ _0831_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2959_ _1421_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__clkbuf_1
Xhold562 instance_0.mem\[3\]\[50\] VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold551 instance_0.mem\[3\]\[37\] VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__dlygate4sd3_1
Xhold540 instance_0.mem\[3\]\[28\] VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__dlygate4sd3_1
Xhold584 instance_0.mem\[0\]\[30\] VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold595 instance_0.mem\[0\]\[25\] VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__dlygate4sd3_1
Xhold573 instance_0.mem\[2\]\[37\] VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput82 net82 VGND VGND VPWR VPWR rdata[14] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput93 net93 VGND VGND VPWR VPWR rdata[24] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3931_ clknet_leaf_24_clk _0157_ VGND VGND VPWR VPWR instance_0.rdata\[43\] sky130_fd_sc_hd__dfxtp_1
X_3862_ clknet_leaf_19_clk _0088_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_2813_ net74 net705 _1335_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3793_ clknet_leaf_15_clk _0019_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[49\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_81_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2744_ instance_1.mem\[1\]\[55\] _1102_ _0957_ instance_1.mem\[3\]\[55\] _1297_ VGND
+ VGND VPWR VPWR _1300_ sky130_fd_sc_hd__a221o_1
X_2675_ instance_1.mem\[1\]\[35\] _1224_ _1177_ instance_1.mem\[3\]\[35\] VGND VGND
+ VPWR VPWR _1251_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4414_ clknet_leaf_37_clk _0640_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4345_ clknet_leaf_39_clk _0571_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_4276_ clknet_leaf_35_clk _0502_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_3227_ _1562_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__clkbuf_1
X_3158_ _1526_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__clkbuf_1
X_2109_ net48 net939 _0855_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__mux2_1
X_3089_ _1489_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold381 instance_1.rdata\[71\] VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__dlygate4sd3_1
Xhold370 instance_1.mem\[1\]\[56\] VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__dlygate4sd3_1
Xhold392 instance_1.mem\[1\]\[53\] VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2460_ instance_0.mem\[1\]\[48\] _1058_ _1048_ instance_0.mem\[0\]\[48\] _1094_ VGND
+ VGND VPWR VPWR _1095_ sky130_fd_sc_hd__a221o_1
X_4130_ clknet_leaf_33_clk _0356_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_2391_ net309 _1024_ _1043_ _1044_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__o22a_1
X_4061_ clknet_leaf_31_clk _0287_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3012_ _1415_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__buf_4
XFILLER_0_64_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3914_ clknet_leaf_32_clk net354 VGND VGND VPWR VPWR instance_0.rdata\[26\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_62_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3845_ clknet_leaf_34_clk _0071_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_89_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3776_ clknet_leaf_31_clk _0002_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[32\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_89_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2727_ instance_1.mem\[1\]\[50\] _1102_ _0957_ instance_1.mem\[3\]\[50\] _1263_ VGND
+ VGND VPWR VPWR _1288_ sky130_fd_sc_hd__a221o_1
XFILLER_0_73_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2658_ instance_1.mem\[1\]\[30\] _1224_ _1177_ instance_1.mem\[3\]\[30\] VGND VGND
+ VPWR VPWR _1239_ sky130_fd_sc_hd__a22o_1
X_2589_ _1189_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
X_4328_ clknet_leaf_47_clk _0554_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_4259_ clknet_leaf_49_clk _0485_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_25_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1960_ _0778_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1891_ instance_0.rdata\[18\] instance_1.rdata\[18\] _0733_ VGND VGND VPWR VPWR _0742_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3630_ _1776_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3561_ _1739_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__buf_4
XFILLER_0_3_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2512_ instance_0.mem\[3\]\[62\] _1016_ _1105_ instance_0.mem\[2\]\[62\] VGND VGND
+ VPWR VPWR _1133_ sky130_fd_sc_hd__a22o_1
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3492_ _1658_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__buf_4
X_2443_ net333 _1056_ _1080_ _1081_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__o22a_1
X_2374_ instance_0.mem\[0\]\[25\] _0947_ _0979_ instance_0.mem\[2\]\[25\] _0999_ VGND
+ VGND VPWR VPWR _1032_ sky130_fd_sc_hd__a221o_1
X_4113_ clknet_leaf_50_clk _0339_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_4044_ clknet_leaf_42_clk _0270_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3828_ clknet_leaf_41_clk _0054_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3759_ _1843_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2090_ _0848_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2992_ net16 net950 _1438_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__mux2_1
X_1943_ _0769_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1874_ _0721_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__buf_4
X_3613_ _1767_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3544_ _1730_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__clkbuf_1
X_3475_ _1694_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2426_ _1069_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2357_ instance_0.mem\[1\]\[21\] _0939_ _0958_ instance_0.mem\[3\]\[21\] VGND VGND
+ VPWR VPWR _1019_ sky130_fd_sc_hd__a22o_1
X_2288_ instance_0.mem\[1\]\[3\] _0965_ _0950_ instance_0.mem\[2\]\[3\] _0960_ VGND
+ VGND VPWR VPWR _0968_ sky130_fd_sc_hd__a221o_1
X_4027_ clknet_leaf_56_clk _0253_ VGND VGND VPWR VPWR instance_1.rdata\[67\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_89_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3260_ net804 net26 _1578_ VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__mux2_1
X_3191_ net627 net40 _1541_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__mux2_1
X_2211_ _0913_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__clkbuf_1
X_2142_ _0854_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__buf_4
X_2073_ net376 net60 _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2975_ net7 net526 _1427_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1926_ _0760_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1857_ _0724_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold700 instance_0.mem\[1\]\[7\] VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__dlygate4sd3_1
Xhold711 instance_0.mem\[3\]\[2\] VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__dlygate4sd3_1
Xhold744 instance_0.mem\[3\]\[42\] VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__dlygate4sd3_1
Xhold722 instance_0.mem\[1\]\[11\] VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__dlygate4sd3_1
Xhold733 instance_0.mem\[3\]\[20\] VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__dlygate4sd3_1
Xhold755 instance_0.mem\[1\]\[24\] VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__dlygate4sd3_1
X_3527_ _1721_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold777 instance_0.mem\[0\]\[6\] VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__dlygate4sd3_1
Xhold788 instance_0.mem\[1\]\[62\] VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__dlygate4sd3_1
Xhold766 instance_0.mem\[0\]\[40\] VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__dlygate4sd3_1
Xhold799 instance_0.mem\[1\]\[71\] VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__dlygate4sd3_1
X_3458_ _1685_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__clkbuf_1
X_3389_ _1648_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__clkbuf_1
X_2409_ _0938_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_4_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold60 _0163_ VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dlygate4sd3_1
Xhold71 instance_0.rdata\[33\] VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dlygate4sd3_1
Xhold82 _0154_ VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold93 instance_0.rdata\[7\] VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_11_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2760_ _1310_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_20_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2691_ _1165_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__buf_4
X_4430_ clknet_leaf_26_clk _0656_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[38\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_2 _1039_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4361_ clknet_leaf_16_clk _0587_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[41\] sky130_fd_sc_hd__dfxtp_1
X_4292_ clknet_leaf_18_clk _0518_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[44\] sky130_fd_sc_hd__dfxtp_1
X_3312_ net857 net23 _1600_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__mux2_1
X_3243_ net482 net67 _1563_ VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__mux2_1
XFILLER_0_67_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3174_ net447 net31 _1530_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2125_ _0868_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
X_2056_ net527 net51 _0828_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_80_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2958_ net48 net878 _1416_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1909_ _0751_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__clkbuf_1
X_2889_ net42 net884 _1379_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__mux2_1
Xhold530 instance_1.mem\[3\]\[2\] VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__dlygate4sd3_1
Xhold563 instance_0.mem\[1\]\[66\] VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__dlygate4sd3_1
Xhold552 instance_0.mem\[3\]\[51\] VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__dlygate4sd3_1
Xhold541 instance_1.mem\[3\]\[53\] VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__dlygate4sd3_1
Xhold574 instance_1.mem\[1\]\[15\] VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__dlygate4sd3_1
Xhold585 instance_0.mem\[0\]\[8\] VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__dlygate4sd3_1
Xhold596 instance_1.mem\[1\]\[23\] VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_86_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput83 net83 VGND VGND VPWR VPWR rdata[15] sky130_fd_sc_hd__clkbuf_4
Xoutput94 net94 VGND VGND VPWR VPWR rdata[25] sky130_fd_sc_hd__clkbuf_4
X_3930_ clknet_leaf_17_clk net238 VGND VGND VPWR VPWR instance_0.rdata\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3861_ clknet_leaf_16_clk _0087_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2812_ _1343_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__clkbuf_1
X_3792_ clknet_leaf_23_clk _0018_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[48\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2743_ instance_1.mem\[0\]\[55\] _0993_ _1248_ instance_1.mem\[2\]\[55\] VGND VGND
+ VPWR VPWR _1299_ sky130_fd_sc_hd__a22o_1
XFILLER_0_81_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2674_ net177 _1232_ _1249_ _1250_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__o22a_1
XFILLER_0_75_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4413_ clknet_leaf_40_clk _0639_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_4344_ clknet_leaf_35_clk _0570_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4275_ clknet_leaf_32_clk _0501_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_3226_ net908 net58 _1552_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__mux2_1
X_3157_ net890 net22 _1519_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__mux2_1
X_2108_ _0859_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
X_3088_ net66 net883 _1482_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__mux2_1
X_2039_ net618 net42 _0817_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold371 instance_1.rdata\[0\] VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__dlygate4sd3_1
Xhold360 instance_0.mem\[2\]\[19\] VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__dlygate4sd3_1
Xhold382 instance_1.rdata\[62\] VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__dlygate4sd3_1
Xhold393 instance_1.mem\[1\]\[54\] VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2390_ instance_0.mem\[1\]\[29\] _1010_ _0988_ instance_0.mem\[3\]\[29\] _1036_ VGND
+ VGND VPWR VPWR _1044_ sky130_fd_sc_hd__a221o_1
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4060_ clknet_leaf_34_clk _0286_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_3011_ _1448_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3913_ clknet_leaf_39_clk net212 VGND VGND VPWR VPWR instance_0.rdata\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_80_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3844_ clknet_leaf_35_clk _0070_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3775_ clknet_leaf_34_clk _0001_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_89_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2726_ instance_1.mem\[0\]\[50\] _1190_ _1248_ instance_1.mem\[2\]\[50\] VGND VGND
+ VPWR VPWR _1287_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2657_ net259 _1232_ _1237_ _1238_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__o22a_1
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2588_ net532 _1187_ _1188_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__mux2_1
X_4327_ clknet_leaf_47_clk _0553_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4258_ clknet_leaf_46_clk _0484_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_3209_ _1553_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__clkbuf_1
X_4189_ clknet_leaf_43_clk _0415_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_53_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold190 _0206_ VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_18_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1890_ _0741_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3560_ _1738_ VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__buf_4
XFILLER_0_11_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2511_ _1132_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
X_3491_ _1702_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__clkbuf_1
X_2442_ instance_0.mem\[0\]\[44\] _1039_ _1040_ instance_0.mem\[2\]\[44\] _1074_ VGND
+ VGND VPWR VPWR _1081_ sky130_fd_sc_hd__a221o_1
X_2373_ instance_0.mem\[1\]\[25\] _1021_ _1030_ instance_0.mem\[3\]\[25\] VGND VGND
+ VPWR VPWR _1031_ sky130_fd_sc_hd__a22o_1
XFILLER_0_52_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4112_ clknet_leaf_47_clk _0338_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_4043_ clknet_leaf_37_clk _0269_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_49_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3827_ clknet_leaf_49_clk _0053_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[11\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3758_ net783 net18 _1838_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2709_ net245 _1261_ _1274_ _1275_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__o22a_1
X_3689_ _1807_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_58_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_67_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_88_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_85_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2991_ _1415_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__buf_4
XFILLER_0_61_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1942_ instance_0.rdata\[42\] instance_1.rdata\[42\] _0766_ VGND VGND VPWR VPWR _0769_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1873_ _0732_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_1
XFILLER_0_56_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3612_ net20 net971 _1762_ VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3543_ net714 net64 _1725_ VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3474_ net393 net28 _1692_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2425_ net380 _1068_ _0935_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__mux2_1
X_2356_ net277 _0990_ _1017_ _1018_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__o22a_1
X_2287_ instance_0.mem\[0\]\[3\] _0963_ _0958_ instance_0.mem\[3\]\[3\] VGND VGND
+ VPWR VPWR _0967_ sky130_fd_sc_hd__a22o_1
XFILLER_0_79_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4026_ clknet_leaf_3_clk net258 VGND VGND VPWR VPWR instance_1.rdata\[66\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_35_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_3_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_85_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2210_ net51 net876 _0910_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__mux2_1
X_3190_ _1543_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__clkbuf_1
X_2141_ _0876_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__clkbuf_1
X_2072_ _0805_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_49_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2974_ _1429_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_32_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1925_ instance_0.rdata\[34\] instance_1.rdata\[34\] _0755_ VGND VGND VPWR VPWR _0760_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1856_ instance_0.rdata\[1\] instance_1.rdata\[1\] _0722_ VGND VGND VPWR VPWR _0724_
+ sky130_fd_sc_hd__mux2_1
Xhold701 instance_1.mem\[0\]\[41\] VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_71_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold712 instance_0.mem\[3\]\[3\] VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__dlygate4sd3_1
Xhold734 instance_1.mem\[2\]\[5\] VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__dlygate4sd3_1
Xhold745 instance_1.mem\[3\]\[11\] VGND VGND VPWR VPWR net893 sky130_fd_sc_hd__dlygate4sd3_1
Xhold723 instance_1.mem\[0\]\[66\] VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__dlygate4sd3_1
X_3526_ net398 net55 _1714_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold767 instance_0.mem\[0\]\[10\] VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__dlygate4sd3_1
Xhold778 instance_1.mem\[3\]\[54\] VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__dlygate4sd3_1
Xhold756 instance_1.mem\[0\]\[32\] VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__dlygate4sd3_1
Xhold789 instance_0.mem\[1\]\[34\] VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__dlygate4sd3_1
X_3457_ net523 net19 _1681_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__mux2_1
X_2408_ instance_0.mem\[3\]\[34\] _1016_ _1008_ instance_0.mem\[2\]\[34\] VGND VGND
+ VPWR VPWR _1057_ sky130_fd_sc_hd__a22o_1
X_3388_ net496 net63 _1644_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__mux2_1
X_2339_ _0951_ _0952_ instance_0.mem\[3\]\[16\] VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_4_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4009_ clknet_leaf_18_clk net322 VGND VGND VPWR VPWR instance_1.rdata\[49\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold50 _0117_ VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 instance_0.rdata\[66\] VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dlygate4sd3_1
Xhold83 instance_1.rdata\[61\] VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dlygate4sd3_1
Xhold72 _0147_ VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_74_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold94 _0121_ VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_55_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_55_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_38_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2690_ instance_1.mem\[3\]\[39\] _1184_ _1248_ instance_1.mem\[2\]\[39\] VGND VGND
+ VPWR VPWR _1262_ sky130_fd_sc_hd__a22o_1
XANTENNA_3 _1105_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4360_ clknet_leaf_21_clk _0586_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_3311_ _1607_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__clkbuf_1
X_4291_ clknet_leaf_17_clk _0517_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[43\] sky130_fd_sc_hd__dfxtp_1
X_3242_ _1570_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__clkbuf_1
X_3173_ _1534_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2124_ net6 net934 _0866_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_46_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_46_clk sky130_fd_sc_hd__clkbuf_8
X_2055_ _0830_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2957_ _1420_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2888_ _1383_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__clkbuf_1
X_1908_ instance_0.rdata\[26\] instance_1.rdata\[26\] _0744_ VGND VGND VPWR VPWR _0751_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold520 instance_0.mem\[1\]\[29\] VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__dlygate4sd3_1
Xhold531 instance_0.mem\[2\]\[61\] VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__dlygate4sd3_1
Xhold553 instance_1.mem\[2\]\[66\] VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__dlygate4sd3_1
Xhold542 instance_1.mem\[0\]\[47\] VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__dlygate4sd3_1
Xhold597 instance_0.mem\[0\]\[17\] VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__dlygate4sd3_1
X_4489_ clknet_leaf_39_clk _0715_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[25\] sky130_fd_sc_hd__dfxtp_1
Xhold564 instance_1.mem\[0\]\[70\] VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__dlygate4sd3_1
Xhold586 instance_1.mem\[3\]\[40\] VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__dlygate4sd3_1
Xhold575 instance_1.mem\[2\]\[37\] VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__dlygate4sd3_1
X_3509_ net467 net46 _1703_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_37_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_37_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_43_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput84 net84 VGND VGND VPWR VPWR rdata[16] sky130_fd_sc_hd__clkbuf_4
Xoutput95 net95 VGND VGND VPWR VPWR rdata[26] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_28_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_28_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_58_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3860_ clknet_leaf_18_clk _0086_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[44\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_14_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2811_ net73 net848 _1335_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__mux2_1
X_3791_ clknet_leaf_19_clk _0017_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2742_ net271 _1295_ _1296_ _1298_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__o22a_1
XFILLER_0_14_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2673_ instance_1.mem\[1\]\[34\] _1244_ _1154_ instance_1.mem\[0\]\[34\] _1230_ VGND
+ VGND VPWR VPWR _1250_ sky130_fd_sc_hd__a221o_1
X_4412_ clknet_leaf_36_clk _0638_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_4343_ clknet_leaf_37_clk _0569_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4274_ clknet_leaf_32_clk _0500_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_3225_ _1561_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__clkbuf_1
X_3156_ _1525_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__clkbuf_1
X_2107_ net37 net880 _0855_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__mux2_1
X_3087_ _1488_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_19_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_8
X_2038_ _0821_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3989_ clknet_leaf_32_clk net260 VGND VGND VPWR VPWR instance_1.rdata\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold350 instance_1.mem\[3\]\[52\] VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__dlygate4sd3_1
Xhold361 instance_0.mem\[0\]\[61\] VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__dlygate4sd3_1
Xhold383 instance_0.mem\[0\]\[41\] VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__dlygate4sd3_1
Xhold394 instance_0.mem\[1\]\[50\] VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__dlygate4sd3_1
Xhold372 instance_1.rdata\[6\] VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3010_ net25 net932 _1438_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3912_ clknet_leaf_35_clk net364 VGND VGND VPWR VPWR instance_0.rdata\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3843_ clknet_leaf_33_clk _0069_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_62_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3774_ clknet_leaf_23_clk _0000_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_2725_ net321 _1261_ _1285_ _1286_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__o22a_1
XFILLER_0_42_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_8_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_8
X_2656_ instance_1.mem\[1\]\[29\] _1192_ _1154_ instance_1.mem\[0\]\[29\] _1230_ VGND
+ VGND VPWR VPWR _1238_ sky130_fd_sc_hd__a221o_1
X_2587_ _1158_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__buf_6
XFILLER_0_59_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4326_ clknet_leaf_55_clk _0552_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_4257_ clknet_leaf_50_clk _0483_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_3208_ net754 net49 _1552_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__mux2_1
X_4188_ clknet_leaf_48_clk _0414_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_3139_ _1516_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_53_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold180 _0119_ VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold191 instance_1.rdata\[2\] VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_83_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3490_ net411 net36 _1692_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__mux2_1
X_2510_ net426 _1131_ _0935_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2441_ instance_0.mem\[1\]\[44\] _1021_ _1030_ instance_0.mem\[3\]\[44\] VGND VGND
+ VPWR VPWR _1080_ sky130_fd_sc_hd__a22o_1
X_2372_ _0956_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__buf_4
X_4111_ clknet_leaf_47_clk _0337_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4042_ clknet_leaf_48_clk _0268_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_67_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3826_ clknet_leaf_46_clk _0052_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3757_ _1842_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__clkbuf_1
X_2708_ instance_1.mem\[1\]\[44\] _1244_ _1103_ instance_1.mem\[2\]\[44\] _1263_ VGND
+ VGND VPWR VPWR _1275_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_30_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3688_ net60 net495 _1806_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__mux2_1
X_2639_ instance_1.mem\[0\]\[24\] _1145_ _1181_ instance_1.mem\[2\]\[24\] _1193_ VGND
+ VGND VPWR VPWR _1226_ sky130_fd_sc_hd__a221o_1
X_4309_ clknet_leaf_2_clk _0535_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[61\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_38_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_72_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2990_ _1437_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1941_ _0768_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1872_ instance_0.rdata\[9\] instance_1.rdata\[9\] _0722_ VGND VGND VPWR VPWR _0732_
+ sky130_fd_sc_hd__mux2_1
X_3611_ _1766_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3542_ _1729_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__clkbuf_1
X_3473_ _1693_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2424_ instance_0.mem\[0\]\[39\] instance_0.mem\[1\]\[39\] instance_0.mem\[2\]\[39\]
+ instance_0.mem\[3\]\[39\] _0973_ _0974_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__mux4_1
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2355_ instance_0.mem\[1\]\[20\] _1010_ _0993_ instance_0.mem\[0\]\[20\] _0999_ VGND
+ VGND VPWR VPWR _1018_ sky130_fd_sc_hd__a221o_1
X_2286_ net205 _0937_ _0964_ _0966_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__o22a_1
X_4025_ clknet_leaf_0_clk _0251_ VGND VGND VPWR VPWR instance_1.rdata\[65\] sky130_fd_sc_hd__dfxtp_1
X_3809_ clknet_leaf_57_clk _0035_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[65\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2140_ net14 net485 _0866_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_49_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2071_ _0838_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2973_ net6 net913 _1427_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1924_ _0759_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1855_ _0723_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold702 instance_0.mem\[2\]\[1\] VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__dlygate4sd3_1
Xhold724 instance_0.mem\[0\]\[44\] VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__dlygate4sd3_1
Xhold746 instance_1.mem\[3\]\[49\] VGND VGND VPWR VPWR net894 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_24_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold735 instance_0.mem\[2\]\[66\] VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__dlygate4sd3_1
Xhold713 instance_1.mem\[3\]\[64\] VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__dlygate4sd3_1
X_3525_ _1720_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__clkbuf_1
Xhold779 instance_1.mem\[0\]\[42\] VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__dlygate4sd3_1
Xhold757 instance_1.mem\[0\]\[16\] VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__dlygate4sd3_1
Xhold768 instance_1.mem\[1\]\[11\] VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__dlygate4sd3_1
X_3456_ _1684_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__clkbuf_1
X_3387_ _1647_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__clkbuf_1
X_2407_ _0936_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__buf_4
X_2338_ instance_0.mem\[0\]\[16\] _0963_ _0942_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__a21o_1
X_2269_ _0945_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__buf_4
X_4008_ clknet_leaf_23_clk net274 VGND VGND VPWR VPWR instance_1.rdata\[48\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold40 _0181_ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 _0180_ VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 instance_0.rdata\[56\] VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 instance_0.rdata\[47\] VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dlygate4sd3_1
Xhold84 _0247_ VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__dlygate4sd3_1
Xhold95 instance_1.rdata\[55\] VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_4 net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3310_ net806 net22 _1600_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__mux2_1
X_4290_ clknet_leaf_17_clk _0516_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3241_ net574 net66 _1563_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__mux2_1
X_3172_ net813 net30 _1530_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__mux2_1
X_2123_ _0867_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2054_ net405 net50 _0828_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_80_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2956_ net37 net828 _1416_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2887_ net41 net502 _1379_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__mux2_1
X_1907_ _0750_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold510 instance_1.rdata\[53\] VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold554 instance_0.mem\[2\]\[13\] VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__dlygate4sd3_1
Xhold532 instance_1.mem\[1\]\[68\] VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__dlygate4sd3_1
Xhold543 instance_0.mem\[1\]\[58\] VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__dlygate4sd3_1
Xhold521 instance_0.mem\[3\]\[27\] VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__dlygate4sd3_1
Xhold587 instance_1.mem\[2\]\[7\] VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__dlygate4sd3_1
Xhold576 instance_1.mem\[1\]\[21\] VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__dlygate4sd3_1
Xhold565 instance_1.mem\[1\]\[25\] VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__dlygate4sd3_1
X_4488_ clknet_leaf_36_clk _0714_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_3508_ _1711_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__clkbuf_1
X_3439_ _1675_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__clkbuf_1
Xhold598 instance_0.mem\[1\]\[69\] VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput85 net85 VGND VGND VPWR VPWR rdata[17] sky130_fd_sc_hd__buf_2
XFILLER_0_37_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput96 net96 VGND VGND VPWR VPWR rdata[27] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2810_ _1342_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__clkbuf_1
X_3790_ clknet_leaf_20_clk _0016_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2741_ instance_1.mem\[0\]\[54\] _1252_ _1103_ instance_1.mem\[2\]\[54\] _1297_ VGND
+ VGND VPWR VPWR _1298_ sky130_fd_sc_hd__a221o_1
XFILLER_0_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2672_ instance_1.mem\[3\]\[34\] _1184_ _1248_ instance_1.mem\[2\]\[34\] VGND VGND
+ VPWR VPWR _1249_ sky130_fd_sc_hd__a22o_1
X_4411_ clknet_leaf_40_clk _0637_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4342_ clknet_leaf_37_clk _0568_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4273_ clknet_leaf_40_clk _0499_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_3224_ net476 net57 _1552_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__mux2_1
.ends
